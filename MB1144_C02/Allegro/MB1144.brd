# Allegro board MB1144.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCDSEG3: length 39.4
  TOP w0.127: v1(86.2,113.67) 86.33,113.54 88.11,113.54 88.61,114.05 88.61,115.19 89.88,116.46 89.88,120.65 89.63,120.9 81.5,120.9 R68.1
  BOTTOM w0.127: v1(86.2,113.67) 86.2,113.54 86.84,112.9 86.84,102.87 85.06,101.09 85.06,97.16 83.82,95.92 CN11.41
LCDSEG4: length 52.8
  TOP w0.127: R66.1 80.74,123.7 81.5,122.94 88.87,122.94 90.65,121.16 90.65,116.08 89.71,115.14 89.71,114.86 v1(89.68,114.83) ; v1(93.44,96.9) 82.3,96.9 CN11.39
  BOTTOM w0.127: v1(93.44,96.9) 93.95,97.41 93.95,110.36 92.81,111.51 92.81,113.16 92.04,113.92 92.04,115.19 91.79,115.44 90.29,115.44 v1(89.68,114.83)
LCDSEG5: length 56.7
  TOP w0.127: 80.36,127.51 81.12,127.51 81.5,127.89 84.42,127.89 85.06,127.25 88.87,127.25 92.68,123.44 92.68,114.81 91.92,114.05 v1(91.92,113.41) ; CN11.37 79.98,95.89 81.38,97.28 92.68,97.28 v1(92.81,97.41)
  BOTTOM w0.127: v1(91.92,113.41) 92.17,113.41 92.55,113.03 92.55,111.25 93.69,110.11 93.69,98.15 92.96,97.41 v1(92.81,97.41)
LCDSEG6: length 65.9
  TOP w0.127: v1(88.87,135.38) 88.36,135.38 84.6,131.62 84.6,130.61 84.17,130.18 81.88,130.18 80.61,128.91 R56.1
  BOTTOM w0.127: v1(88.87,135.38) 94.15,135.38 94.84,134.7 98.7,134.7 99.92,133.48 99.92,111.63 96.74,108.46 96.67,108.46 96.03,107.82 96.03,98.81 93.11,95.89 CN11.47
LCDSEG7: length 193.2
  TOP w0.127: v1(72.36,48.9) 72.36,48.77 72.49,48.64 72.49,48.23 U24.6 ; v1(112.97,87.35) 112.74,87.12 RS1.9 ; v1(43.28,112.14) 42.77,112.65 42.77,120.14 44.04,121.41 44.04,123.06 45.56,124.59 48.1,124.59 48.36,124.84 50.77,124.84 51.07,125.15 U7.133 ; v1(108.25,94.82) 107.99,95.07 94.89,95.07 94.53,94.72 90.19,94.72 89.02,95.89 CN11.45 87.73,95.89 86.07,94.23 70.07,94.23 69.82,94.49 67.79,94.49 67.61,94.67 65.3,94.67 64.36,93.73 60.8,93.73 v1(60.42,93.34) 60.29,93.22 55.59,93.22 54.71,92.33 49.5,92.33 48.86,91.69 36.8,91.69 v1(35.91,90.81)
  BOTTOM w0.127: v1(112.97,87.35) 112.93,87.31 112.5,87.31 108.93,90.88 108.93,94.13 v1(108.25,94.82) ; v1(43.28,112.14) 42.03,112.14 34.44,104.55 34.44,93.55 35.91,92.08 v1(35.91,90.81) ; v1(60.42,93.34) 59.53,92.46 59.53,77.39 62.33,74.6 62.33,67.77 64.56,65.53 64.56,59.56 65.25,58.88 65.25,51.05 65.82,50.48 65.82,47.19 66.07,46.93 66.85,46.93 67.13,47.21 67.13,49.1 67.76,49.73 69.06,49.73 69.89,48.9 v1(72.36,48.9)
LCDSEG8: length 243.3
  TOP w0.127: RS1.5 112,86.11 112.02,86.08 112.57,86.08 112.92,85.72 v1(112.97,85.72) ; v1(43.28,112.9) 43.02,113.16 43.02,119.89 44.29,121.16 44.29,122.81 45.69,124.21 48.1,124.21 48.36,124.46 50.9,124.46 51.08,124.65 U7.134 ; v1(53.31,92.84) 54.32,92.84 54.96,93.47 59.91,93.47 60.42,93.98 64.23,93.98 65.25,95 67.66,95 67.91,94.74 70.07,94.74 70.33,94.49 85.69,94.49 86.36,95.15 CN11.43 ; v1(66.66,48.19) 65.97,48.19 65.62,47.85 U23.19 ; v1(108.71,88.82) 108.45,89.08 v1(102.69,89.08) ; v1(35.91,87.5) 38.45,87.5 42.26,83.69 44.67,83.69 46.81,85.83 50.54,85.83 50.95,86.23 52.65,86.23 v1(53.18,86.77)
  BOTTOM w0.127: v1(66.66,48.19) 66.54,48.31 66.54,49.27 67.64,50.38 71.76,50.38 72.1,50.04 78.96,50.04 79.6,49.4 95.65,49.4 96.44,48.62 109.16,48.62 110.97,50.42 110.97,59.31 111.22,59.56 111.22,68.48 115.54,72.8 115.54,78.11 115.34,78.31 115.34,78.66 115.54,78.87 115.54,83.16 v1(112.97,85.72) 112.77,85.93 112.31,85.93 111.07,87.17 109.16,87.17 108.68,87.66 108.68,88.8 v1(108.71,88.82) ; v1(53.31,92.84) 53.31,90.3 52.57,89.56 52.57,87.43 53.18,86.82 v1(53.18,86.77) ; v1(102.69,89.08) 102.13,89.08 99.28,86.23 85.82,86.23 84.55,87.5 84.55,93.22 86.36,95.03 CN11.43 ; v1(43.28,112.9) 42.41,112.9 34.18,104.67 34.18,93.42 35.4,92.2 35.4,88.01 v1(35.91,87.5)
LCDSEG9: length 65.2
  TOP w0.127: v1(28.3,94.16) 28.37,94.23 46.61,94.23 CN11.13 ; U7.135 50.96,124.15 50.26,123.44 v1(50.01,123.44)
  BOTTOM w0.127: v1(28.3,94.16) 28.52,94.39 28.52,99.81 29.28,100.57 29.28,108.3 40.35,119.38 42.89,119.38 46.45,122.94 49.5,122.94 v1(50.01,123.44)
LCDSEG10: length 126.7
  TOP w0.127: v1(62.73,101.75) 62.73,101.7 61.69,100.66 58.39,100.66 57.58,101.47 48.84,101.47 46.68,99.31 46.68,96.85 45.72,95.89 CN11.11 ; v1(65.75,94.13) 65.91,93.98 86.46,93.98 86.71,94.23 93.72,94.23 v1(93.92,94.03) ; R50.1 80.74,135.64 81.76,134.62 84.68,134.62 88.61,138.56 v1(88.87,138.56)
  BOTTOM w0.127: v1(93.92,94.03) 96.69,96.8 96.69,107.26 100.43,111 100.43,134.9 98.04,137.29 94.08,137.29 92.17,139.19 89.5,139.19 v1(88.87,138.56) ; v1(65.75,94.13) 64.92,94.97 64.92,99.01 62.73,101.19 v1(62.73,101.75)
LCDSEG11: length 205.8
  TOP w0.127: v1(87.34,64.9) 86.46,65.79 71.52,65.79 67.2,61.47 61.28,61.47 60.01,60.2 51.73,60.2 48.79,63.14 47.36,63.14 v1(47.21,62.99) ; R48.1 80.99,137.16 81.76,136.4 84.68,136.4 88.49,140.21 100.93,140.21 101.31,139.83 102.71,139.83 104.24,138.3 109.32,138.3 109.38,138.24 109.76,138.24 v1(110.08,137.92)
  BOTTOM w0.127: v1(110.08,137.92) 109.9,137.92 108.3,136.32 108.3,126.87 108.05,126.62 108.05,116 107.26,115.21 107.26,115.19 107.05,114.99 107.05,111.99 107.03,111.96 107.03,111.63 108.6,110.06 108.6,96.32 107.61,95.33 107.61,94.31 106.95,93.65 106.95,80.44 108.12,79.27 108.12,69.29 103.73,64.9 v1(87.34,64.9) ; v1(47.21,62.99) 47.21,69.47 44.06,72.62 44.06,93.75 43.18,94.63 CN11.9
LCDSEG12: length 176.4
  TOP w0.127: v1(22.98,133.93) 22.98,134.04 23.97,135.03 23.97,137.67 25.88,139.57 v1(29.94,139.57) ; v1(52.14,71.53) 51.96,71.35 51.12,71.35 50.9,71.12 32.1,71.12 v1(31.77,70.79) ; R39.2 v1(71.85,145.67)
  BOTTOM w0.127: CN11.19 55.88,93.5 54.71,92.33 54.71,86.11 55.01,85.8 55.01,74.65 52.14,71.78 v1(52.14,71.53) ; v1(22.98,133.93) 22.52,133.48 22.52,128.96 24.86,126.62 24.86,124.82 24.48,124.43 24.48,114.05 23.62,113.18 23.62,111.48 23.98,111.12 23.98,103.25 21.48,100.75 21.48,97.82 23.34,95.96 23.34,93.21 28.11,88.44 28.11,75.79 28.31,75.59 28.31,74.65 31.77,71.2 v1(31.77,70.79) ; v1(71.85,145.67) 71.85,143.38 70.2,141.73 62.45,141.73 60.17,139.45 57.8,139.45 55.9,141.35 52.29,141.35 50.51,139.57 v1(29.94,139.57)
LCDSEG13: length 158
  TOP w0.127: R38.1 v1(69.31,145.67) ; v1(52.29,86.74) 52.17,86.61 50.95,86.61 50.41,86.08 46.65,86.08 44.52,83.95 42.39,83.95 38.32,88.01 33.12,88.01 30.19,85.09 v1(22.32,85.09) ; v1(32.61,140.08) 25.37,140.08 23.46,138.18 23.46,135.08 22.37,133.99 22.37,116.51 21.18,115.32 21.18,111.38 v1(21.3,111.25)
  BOTTOM w0.127: v1(52.29,86.74) 52.29,87 52.19,87.1 52.19,89.81 52.8,90.42 52.8,93.09 53.34,93.63 CN11.17 ; v1(22.32,85.09) 21.56,85.85 21.56,88.17 17.57,92.15 17.57,102.23 16.48,103.33 16.48,104.78 17.57,105.87 17.57,107.67 21.15,111.25 v1(21.3,111.25) ; v1(69.31,145.67) 69.44,145.67 71.09,144.02 71.09,143 70.07,141.99 62.2,141.99 60.04,139.83 57.8,139.83 55.9,141.73 51.91,141.73 50.26,140.08 v1(32.61,140.08)
LCDSEG14: length 56.7
  TOP w0.127: v1(65.88,125.48) 65.88,129.16 71.25,134.53 U7.75 ; v1(57.63,100.46) 57.07,99.9 57.07,97.66 56.74,97.33 55.21,97.33 54.78,96.9 51.82,96.9 CN11.15
  BOTTOM w0.127: v1(57.63,100.46) 57.63,101.35 58.97,102.69 58.97,110.06 59.79,110.87 59.79,113.67 59.28,114.17 59.28,114.81 59.79,115.32 59.79,121.82 63.82,125.86 65.63,125.86 65.88,125.6 v1(65.88,125.48)
LCDSEG15: length 49.9
  TOP w0.127: v1(65.88,124.59) 65.37,125.09 65.37,129.16 70.75,134.53 U7.76
  BOTTOM w0.127: CN11.25 63.21,95.89 62.58,96.52 62.58,98.93 60.75,100.76 60.75,108.79 61.94,109.98 61.94,121.31 63.19,122.56 64.36,122.56 65.88,124.08 v1(65.88,124.59)
LCDSEG16: length 51.4
  TOP w0.127: CN11.23 60.22,95.89 59.07,94.74 54.2,94.74 53.82,94.36 52.04,94.36 51.28,93.6 48.61,93.6 v1(48.23,93.22) ; v1(44.44,110.97) 44.55,111.07 44.55,120.27 45.69,121.41 49.5,121.41 50.23,122.15 U7.139
  BOTTOM w0.127: v1(44.44,110.97) 44.44,109.25 47.36,106.33 47.36,94.08 v1(48.23,93.22)
LCDSEG17: length 213.9
  TOP w0.127: v1(107.79,93.85) 107.54,94.11 105.78,94.11 105.38,94.51 96.64,94.51 94.84,92.71 64.33,92.71 62.76,91.14 62.76,89.84 62.2,89.28 56.36,89.28 56.1,89.53 v1(56.1,89.66) ; v1(113.61,87.3) 113.61,87.33 112.9,86.61 112,86.61 RS1.7 ; U7.110 55.85,136.65 57.42,135.08 57.42,132.05 56.22,130.84 56.22,126.35 v1(56.16,126.3) ; v1(64.93,48.51) 64.93,48.45 64.48,48.01 64.48,47.5 64.62,47.36 U23.17 ; v1(31.69,92.86) 32.05,93.22 47.21,93.22 48.1,94.11 51.02,94.11 51.78,94.87 53.56,94.87 54.45,95.76 54.45,95.89 55.47,96.9 57.4,96.9 CN11.21
  BOTTOM w0.127: v1(31.69,92.86) 31.69,93.25 30.73,94.22 30.73,99.33 31.2,99.8 31.2,107.62 40.68,117.09 40.68,117.19 41.09,117.6 43.85,117.6 47.06,120.81 50.02,120.81 50.48,121.27 51.72,121.27 54.85,124.41 54.85,124.54 56.16,125.85 v1(56.16,126.3) ; v1(113.61,87.3) 113.61,87.33 113.13,86.84 112.59,86.84 108.68,90.75 108.68,92.96 v1(107.79,93.85) ; v1(64.93,48.51) 64.81,48.63 64.81,58.72 63.6,59.94 63.6,65.66 61.97,67.28 61.97,72.11 57.37,76.71 57.37,85.34 56.86,85.85 56.86,88.9 v1(56.1,89.66) 56.1,91.19 57.5,92.58 57.5,94.96 CN11.21
LCDSEG18: length 26.2
  TOP w0.127: R97.1 70.71,108.97 70.07,108.33 v1(70.07,108.03)
  BOTTOM w0.127: v1(70.07,108.03) 70.07,108.33 69.56,108.84 64.23,108.84 62.6,107.21 62.6,104.55 67.2,99.95 69.44,99.95 70.03,99.36 70.03,96.98 CN11.31
LCDSEG19: length 26.1
  TOP w0.127: v1(70.71,107.95) 71.22,107.95 R98.1
  BOTTOM w0.127: CN11.29 67.13,97.34 67.13,99.59 62.3,104.42 62.3,107.44 64.08,109.22 69.95,109.22 70.71,108.46 v1(70.71,107.95)
LCDSEG20: length 27.7
  TOP w0.127: R99.1 73.76,108.58 72.99,107.82 v1(71.85,107.82)
  BOTTOM w0.127: CN11.27 65.81,95.89 65.17,96.52 65.17,99.85 65.12,99.9 65.12,101.21 62.02,104.3 62.02,107.7 63.93,109.6 70.2,109.6 71.34,108.46 71.34,108.2 71.72,107.82 v1(71.85,107.82)
LCDSEG21: length 56.9
  TOP w0.127: U7.137 51.74,123.15 51.53,122.94 49.88,122.94 49.37,123.44 49.37,123.7 49.12,123.95 46.07,123.95 44.67,122.56 44.67,121.03 43.94,120.29 43.94,107.65 v1(44.06,107.52)
  BOTTOM w0.127: v1(44.06,107.52) 44.49,107.09 44.49,105.05 43.48,104.04 43.48,101.88 42.31,100.71 42.31,94.97 43.78,93.5 43.78,82.96 42.11,81.28 42.11,79.17 43.17,78.11 CN14.9
LCDSEG22: length 92.8
  TOP w0.127: v1(90.9,114.55) 90.9,115.19 91.66,115.95 91.66,120.52 91.64,120.55 91.64,121.79 88.46,124.97 84.13,124.97 83.81,125.28 ; CN14.11 46.07,78.11 47.24,79.27 49.07,79.27 49.68,79.88 49.68,81.38 50.77,82.47 50.77,84.84 51.4,85.47 61.56,85.47 62.4,84.63 70.1,84.63 70.96,85.5 83.05,85.5 83.76,86.21 83.76,89.56 85.52,91.31 v1(85.95,91.31)
  BOTTOM w0.127: v1(85.95,91.31) 85.95,91.72 87.98,93.75 87.98,101.3 89.78,103.1 89.78,103.78 89.81,103.81 89.81,113.59 90.77,114.55 v1(90.9,114.55)
LCDSEG23: length 97.7
  TOP w0.127: CN14.13 49.93,79.78 49.93,81.18 51.02,82.27 51.02,84.71 51.53,85.22 61.41,85.22 62.27,84.35 70.2,84.35 71.09,85.24 83.18,85.24 84.02,86.08 84.02,89.43 85.13,90.55 85.82,90.55 v1(86.71,91.44) ; 80.36,125.35 80.74,125.35 81.76,126.36 84.42,126.36 84.68,126.62 87.98,126.62 92.17,122.43 92.17,115.06 91.03,113.92 v1(90.9,113.92)
  BOTTOM w0.127: v1(90.9,113.92) 90.9,111.51 92.55,109.86 92.55,104.62 90.01,102.08 90.01,95.33 86.71,92.02 v1(86.71,91.44)
LCDSEG24: length 101.8
  TOP w0.127: v1(42.54,103.07) 42.44,103.07 42.06,103.45 42.06,105.74 40.61,107.19 40.61,109.09 40.86,109.35 40.86,117.86 37.56,121.16 37.56,128.91 45.31,136.65 45.31,146.81 46.96,148.46 56.48,148.46 59.4,145.54 R36.1 ; CN14.15 50.79,78.11 49.14,76.45 42.92,76.45 v1(42.69,76.23)
  BOTTOM w0.127: v1(42.54,103.07) 42.49,103.07 42.06,102.64 42.06,94.64 41.83,94.41 41.83,78.03 42.72,77.14 42.72,76.25 v1(42.69,76.23)
LCDSEG25: length 104.8
  TOP w0.127: CN14.17 52.32,79.12 50.51,79.12 49.93,78.54 49.93,77.62 49.02,76.71 41.88,76.71 v1(41.37,76.2) ; R33.1 58.01,146.07 56,148.08 47.21,148.08 45.69,146.56 45.69,136.4 37.94,128.65 37.94,121.16 41.12,117.98 41.12,109.22 40.86,108.97 40.86,107.44 42.61,105.69 v1(42.61,103.81)
  BOTTOM w0.127: v1(42.61,103.81) 41.8,103 41.8,94.84 41.57,94.61 41.57,76.4 v1(41.37,76.2)
LCDSEG26: length 112.3
  TOP w0.127: v1(59.4,140.84) 59.4,140.59 59.75,140.24 U7.98 59.75,132.79 57.63,130.66 v1(57.63,126.49) ; v1(33.5,75.44) 33.75,75.69 43.66,75.69 44.16,76.2 49.37,76.2 50.13,76.96 53.64,76.96 54.78,78.11 CN14.19
  BOTTOM w0.127: v1(33.5,75.44) 33.88,75.82 33.88,91.52 30.98,94.41 30.98,99.22 31.46,99.7 31.46,107.51 41.09,117.14 43.75,117.14 47.17,120.56 50.12,120.56 50.58,121.02 51.82,121.02 55.11,124.3 55.11,124.43 56.51,125.83 56.73,125.83 57.4,126.49 v1(57.63,126.49) ; v1(59.4,140.84) 59.68,140.84 60.29,141.45 60.29,142.88 60.04,143.13 58.67,143.13 58.16,143.64 58.16,144.38
LCDSEG27: length 115.2
  TOP w0.127: v1(34.51,74.17) 35.27,74.93 44.04,74.93 44.55,75.44 49.8,75.44 50.57,76.2 54.17,76.2 54.58,76.61 56.92,76.61 CN14.21 ; v1(58.01,141.1) 58.01,140.69 58.39,140.31 58.82,140.31 59.25,139.88 U7.99 59.25,132.65 57.12,130.52 57.12,126.36 v1(57.63,125.86)
  BOTTOM w0.127: v1(58.01,141.1) 57.75,141.1 56.26,142.59 56.26,144.38 ; v1(57.63,125.86) 57.35,125.58 56.61,125.58 55.36,124.33 55.36,124.15 51.98,120.76 50.69,120.76 50.23,120.3 47.27,120.3 43.78,116.81 41.12,116.81 31.79,107.49 31.79,99.67 31.24,99.12 31.24,94.59 34.13,91.69 34.13,74.55 v1(34.51,74.17)
LCDSEG28: length 68.8
  TOP w0.127: v1(64.87,125.35) 64.87,129.16 70.25,134.54 U7.77
  BOTTOM w0.127: CN14.23 60.93,78.11 59.91,79.12 59.91,81.15 61.18,82.42 61.18,93.22 59.28,95.12 59.28,99.19 59.23,99.24 59.23,109.8 60.04,110.62 60.04,113.79 59.53,114.3 59.53,114.68 60.04,115.19 60.04,121.69 63.95,125.6 64.61,125.6 v1(64.87,125.35)
LCDSEG29: length 68.7
  TOP w0.127: U7.78 69.75,135.06 64.36,129.67 64.36,125.22 v1(64.87,124.71)
  BOTTOM w0.127: CN14.25 62.45,79.15 62.45,80.77 61.69,81.53 61.69,93.09 59.53,95.25 59.53,99.31 59.48,99.36 59.48,109.55 60.67,110.74 60.67,121.95 63.95,125.22 64.36,125.22 v1(64.87,124.71)
LCDSEG30: length 68.1
  TOP w0.127: v1(64.23,124.71) 63.98,124.97 63.98,129.92 69.25,135.2 U7.79
  BOTTOM w0.127: CN14.27 64.61,79.54 64.61,80.9 62.07,83.44 62.07,93.09 59.79,95.38 59.79,99.44 59.73,99.49 59.73,109.42 60.93,110.62 60.93,121.82 63.82,124.71 v1(64.23,124.71)
LCDSEG31: length 70.6
  TOP w0.127: U7.80 68.75,135.08 63.72,130.05 63.72,124.59 64.1,124.21 64.61,124.21 v1(64.87,123.95)
  BOTTOM w0.127: CN14.29 67.02,79.66 67.02,86.49 63.85,89.66 63.85,91.69 60.04,95.5 60.04,99.57 59.99,99.62 59.99,109.3 61.18,110.49 61.18,121.69 63.7,124.21 64.61,124.21 v1(64.87,123.95)
LCDSEG32: length 69.9
  TOP w0.127: U7.81 68.25,135.21 63.34,130.3 63.34,124.59 64.1,123.83 v1(64.1,123.7)
  BOTTOM w0.127: CN14.31 69.98,79.25 69.98,84.17 65.25,88.9 65.25,92.33 61.82,95.76 61.82,98.93 60.24,100.51 60.24,109.17 61.44,110.36 61.44,121.56 63.57,123.7 v1(64.1,123.7)
LCDSEG33: length 70.9
  TOP w0.127: v1(64.1,123.06) 63.09,124.08 63.09,130.94 67.75,135.6 U7.82
  BOTTOM w0.127: v1(64.1,123.06) 63.32,123.06 61.69,121.44 61.69,110.24 60.5,109.04 60.5,100.63 62.12,99.01 62.12,95.96 65.5,92.58 65.5,89.15 72.26,82.39 72.26,79.5 CN14.33
LCDSEG34: length 129.8
  TOP w0.127: v1(35.91,74.42) 36.16,74.68 44.29,74.68 44.8,75.18 49.93,75.18 50.69,75.95 54.3,75.95 54.71,76.35 57.4,76.35 58.16,77.11 75.21,77.11 CN14.35 ; v1(58.64,126.49) 58.52,126.62 58.52,130.68 60.67,132.84 63.34,132.84 66.52,136.02 66.52,138.05 66.25,138.31 U7.85
  BOTTOM w0.127: v1(35.91,74.42) 34.64,75.69 34.64,92.08 31.74,94.97 31.74,98.9 32.3,99.46 32.3,107.24 41.14,116.08 43.78,116.08 46.83,119.13 51.06,119.13 55.87,123.94 55.87,124.12 56.75,124.99 58.41,124.99 59.02,125.6 59.02,126.11 v1(58.64,126.49)
LCDSEG35: length 133.5
  TOP w0.127: U7.86 65.75,138.43 66.26,137.92 66.26,136.14 63.21,133.1 60.42,133.1 58.13,130.81 58.13,126.24 v1(58.52,125.86) ; v1(35.91,73.66) 36.67,74.42 44.42,74.42 44.93,74.93 50.06,74.93 50.82,75.69 54.43,75.69 54.83,76.1 58.21,76.1 58.97,76.86 77.5,76.86 CN14.37
  BOTTOM w0.127: v1(35.91,73.66) 34.39,75.18 34.39,91.85 31.49,94.74 31.49,99.01 32.05,99.57 32.05,107.36 41.02,116.33 43.67,116.33 46.83,119.49 51.06,119.49 55.62,124.04 55.62,124.22 56.72,125.32 58.24,125.32 58.52,125.6 v1(58.52,125.86)
LCDSEG36: length 93.4
  TOP w0.127: v1(44.98,73.89) 44.98,74.47 45.18,74.68 50.18,74.68 50.95,75.44 54.55,75.44 54.96,75.84 58.36,75.84 59.1,76.58 79.76,76.58 CN14.39 ; U7.141 50.25,121.15 50.01,120.9 46.07,120.9 45.31,120.14 45.31,106.91 v1(44.95,106.55)
  BOTTOM w0.127: v1(44.95,106.55) 44.95,104.93 44.04,104.01 44.04,94.51 44.34,94.21 44.34,74.52 v1(44.98,73.89)
LCDSEG37: length 93.5
  TOP w0.127: CN14.41 82.04,76.33 59.28,76.33 58.54,75.59 55.09,75.59 54.68,75.18 51.15,75.18 50.39,74.42 48.69,74.42 v1(47.82,73.56) ; U7.142 51.41,120.65 51.28,120.78 50.39,120.78 50.26,120.65 46.32,120.65 45.69,120.02 45.69,106.07 v1(46.58,105.18)
  BOTTOM w0.127: v1(46.58,105.18) 46.86,104.9 46.86,87.63 48.48,86 48.48,82.55 47.39,81.46 47.39,73.99 v1(47.82,73.56)
LCDSEG38: length 73.8
  TOP w0.127: CN14.43 84.33,76.07 59.66,76.07 58.9,75.31 55.19,75.31 54.81,74.93 51.61,74.93 v1(51.05,74.37) ; R103.2 51.15,107.82 v1(51.28,107.7)
  BOTTOM w0.127: v1(51.05,74.37) 51.07,74.4 51.07,75.36 52.19,76.48 52.19,83.03 50.13,85.09 50.13,92.1 52.22,94.18 52.22,106.76 v1(51.28,107.7)
LCDSEG39: length 75.2
  TOP w0.127: v1(51.71,74.37) 52.01,74.68 54.93,74.68 55.31,75.06 59.28,75.06 60.04,75.82 86.61,75.82 CN14.45 ; R104.2 v1(52.67,107.82)
  BOTTOM w0.127: v1(51.71,74.37) 51.71,75.49 52.44,76.23 52.44,83.16 50.39,85.22 50.39,91.8 52.47,93.88 52.47,100.79 52.67,100.99 v1(52.67,107.82)
LED_STLINK: length 77.9
  TOP w0.127: U23.30 65.55,50.3 v1(65.36,50.1) ; v1(59.1,43.23) 58.57,43.23 53.18,37.85 53.18,31.5 50.01,28.32 41.37,28.32 40.35,27.3 40.35,22.1 34.13,15.88 34.13,14.73 32.23,12.83 22.19,12.83 20.16,10.79 R254.1 R253.1
  BOTTOM w0.127: v1(59.1,43.23) 59.1,43.31 59.02,43.38 59.02,43.69 62.38,47.04 65.04,47.04 65.43,47.43 65.43,49.9 65.36,49.97 v1(65.36,50.1)
MICROAB_N: length 4.3
  TOP w0.155: R3.1 29.31,165.99 29.44,165.85 D1.D1 29.63,165.91 29.63,167.44 29.49,167.58 CN1.2
MICROAB_P: length 5.5
  TOP w0.155: R4.1 31.46,165.99 31.21,166.24 30.45,166.24 30.07,165.87 D1.C1 30.01,165.91 30.01,167.33 30.14,167.46 CN1.3
NE3_1DELAY: length 13.9
  TOP w0.127: U21.38 58.01,71.11 58.01,70.18 58.1,70.09 v1(58.1,69.77) ; U21.3 53.89,65.33 54.1,65.53 55.09,65.53 v1(55.59,66.04)
  BOTTOM w0.127: 58.16,70.89 58.16,69.84 v1(58.1,69.77) 58.1,69.3 55.59,66.8 v1(55.59,66.04) 55.09,65.53 55.09,64.39 55.72,63.75
NE3_2DELAY: length 2.8
  TOP w0.127: v1(57.96,62.26) 57.96,62.33 57.88,62.41 57.88,63.64 U21.11
  BOTTOM w0.127: v1(57.96,62.26) 57.85,62.26 57.37,62.74 57.37,63.37
NETB2_2: length 13.9
  TOP w0.127: R244.1 R245.1 74.45,12.77 B2.3 B2.2
NETB3_1: length 14
  TOP w0.127: U33.3 81.38,16.89 83.41,14.86 83.41,13.59 R248.1 82.01,10.67 82.01,7.3 B3.1
NETB3_2: length 24.6
  TOP w0.127: U33.1 80.38,13.57 R246.2 79.47,11.18 79.47,6.6 83.41,2.67 85.06,2.67 86.46,4.06 86.46,4.7 85.69,5.46 84.42,5.46 B3.2
NETB3_3: length 18.6
  TOP w0.127: B3.3 84.37,3.43 83.79,3.43 80.61,6.6 80.61,10.92 R247.1 81.76,13.59 81.76,15.76 80.88,16.64 U33.2
NETB3_4: length 14.4
  TOP w0.127: B3.4 89.2,8.26 87.34,8.26 86.07,9.53 R249.1 84.8,14.1 84.8,14.99 83.79,16 82.9,16 81.88,17.02 U33.4
NETB3_5: length 3.5
  TOP w0.127: R251.2 89,10.03 B3.5
NETB3_6: length 10.9
  TOP w0.127: B3.6 87.73,10.74 R250.1 86.96,13.59 86.96,15.24 85.82,16.38 83.15,16.38 82.38,17.16 U33.5
NETBT1_1: length 50.6
  TOP w0.127: v1(26.44,49.53) 26.44,49.48 26.84,49.07 BT1.1
  BOTTOM w0.127: v1(26.44,49.53) 26.33,49.63 26.33,67.41 21.43,72.31 21.43,75.95 21.3,76.07 21.3,82.93 20.03,84.2 JP12.3
NETC1_2: length 220.3
  TOP w0.127: CN2.33 46.2,167.89 C1.2 44.67,167.89 42.64,167.89 41.5,166.75 41.5,137.41 34.89,130.81 34.89,119.51 37.53,116.87 37.53,107.8 37.1,107.37 37.1,103.8 40.28,100.62 45.27,100.62 v1(45.43,100.46) ; v1(49.37,66.29) 50.39,67.31 54.83,67.31 55.59,68.07 85.19,68.07 85.69,68.58 85.69,68.96 v1(85.57,69.09)
  BOTTOM w0.127: v1(49.37,66.29) 49.24,66.29 48.87,66.66 48.87,69.59 46.58,71.88 46.58,83.95 45.18,85.34 45.18,94.61 44.82,94.97 44.82,99.85 v1(45.43,100.46) ; v1(85.57,69.09) 87.34,70.87 87.34,81.41 80.36,88.39 80.36,100.2 80.87,100.71 80.87,105.41 81.43,105.97 81.43,107.01 80.61,107.82 80.61,113.92 79.22,115.32 79.22,115.95 78.58,116.59 74.77,116.59
NETC2_2: length 219
  TOP w0.127: v1(49.37,67.06) 49.88,67.56 54.71,67.56 55.47,68.33 84.17,68.33 84.68,68.83 84.68,68.96 v1(84.8,69.09) ; v1(45.82,100.97) 40.37,100.97 37.39,103.95 37.39,107.16 37.81,107.58 37.81,117.07 35.15,119.74 35.15,130.56 41.88,137.29 41.88,165.74 42.64,166.5 44.8,166.5 C2.2 52.8,165.86 CN2.34
  BOTTOM w0.127: v1(49.37,67.06) 49.37,69.85 46.83,72.39 46.83,86.74 46.58,87 46.58,100.2 v1(45.82,100.97) ; 74.59,117.85 77.95,117.85 79.72,116.08 79.72,115.44 80.87,114.3 80.87,108.08 81.88,107.06 81.88,105.94 81.5,105.56 81.5,99.57 82.14,98.93 82.14,92.84 81.63,92.33 81.63,87.63 87.73,81.53 87.73,70.36 85.95,68.58 85.31,68.58 v1(84.8,69.09)
NETC3_1: length 150.7
  TOP w0.127: v1(91.41,114.94) 91.41,115.06 91.92,115.57 91.92,120.65 91.89,120.68 91.89,122.2 88.36,125.73 SB17.1 ; R7.2 44.04,164.34 44.04,163.32 43.02,163.32 42.26,162.56 42.26,137.16 35.4,130.3 35.4,120.02 38.07,117.35 38.07,107.43 37.69,107.04 37.69,104.14 39.97,101.85 45.61,101.85 46.2,102.44 60.55,102.44 60.9,102.08 61.66,102.08 62.45,102.87 63.21,102.87 64.03,102.06 72.41,102.06 74.24,103.89 84.52,103.89 85.92,102.49 91.03,102.49 v1(91.15,102.36)
  BOTTOM w0.127: v1(91.41,114.94) 91.41,111.51 92.93,109.98 92.93,104.39 91.15,102.62 v1(91.15,102.36)
NETC4_2: length 136.2
  TOP w0.127: 43.53,160.4 43.4,160.27 43.4,159.51 42.51,158.62 42.51,137.03 35.66,130.18 35.66,120.4 38.32,117.73 38.32,107.19 37.94,106.81 37.94,104.39 40.23,102.11 45.46,102.11 46.04,102.69 60.7,102.69 61,102.39 61.59,102.39 62.33,103.12 63.34,103.12 63.95,102.51 72.18,102.51 74.16,104.5 v1(82.21,104.5) ; CN2.31 54.83,166.88 54.83,164.47 53.94,163.58 48.48,163.58 47.72,162.81 44.55,162.81 C4.2 43.78,160.78
  BOTTOM w0.127: 81.12,115.44 81.12,108.2 82.39,106.93 82.39,104.67 v1(82.21,104.5)
NETC5_2: length 47.3
  TOP w0.127: CN2.30 57.88,165.35 54.71,162.18 54.07,162.18 C5.2 52.8,160.53 v1(53.18,160.15) 52.8,159.77 R20.1 ; v1(70.58,143.13) 70.71,143 71.47,143 72.1,142.37 SB3.1
  BOTTOM w0.127: v1(53.18,160.15) 53.44,159.89 53.44,144.58 57.93,140.08 59.79,140.08 62.07,142.37 69.69,142.37 70.45,143.13 v1(70.58,143.13)
NETC6_2: length 159.9
  TOP w0.127: v1(38.5,106.27) 38.58,106.35 38.58,117.86 35.91,120.52 35.91,129.92 42.77,136.78 42.77,154.69 47.59,159.51 C6.2 R12.2 ; v1(87.09,93.73) 86.84,93.47 61.56,93.47 60.93,92.84 55.59,92.84 54.71,91.95 49.63,91.95 49.12,91.44 38.14,91.44 v1(37.76,91.06) ; 87.09,122.05 87.1,122.06 89.37,122.06 90.39,121.03 90.39,116.2 89.22,115.04 89.22,114.6 v1(89.66,114.17)
  BOTTOM w0.127: v1(87.09,93.73) 87.73,94.36 87.73,101.47 89.5,103.25 89.5,114.02 v1(89.66,114.17) ; v1(38.5,106.27) 37.23,105 37.23,94.44 37.43,94.23 37.43,91.39 v1(37.76,91.06)
NETC7_2: length 72.6
  TOP w0.127: CN2.1 95.09,166.75 95.09,160.27 C7.2 R14.1
  BOTTOM w0.127: CN2.1 91.66,170.18 78.45,170.18 77.24,168.96 77.24,164.95 75.99,163.7 57.25,163.7 55.85,162.31 55.85,159.99 56.81,159.03 56.81,147.93 56.24,147.35 56.24,145.36
NETC8_1: length 1.3
  TOP w0.127: SB1.1 46.45,160.53 C8.1
NETC9_2: length 112.2
  TOP w0.127: v1(61.28,102.87) 61.18,102.97 45.87,102.97 45.26,102.36 40.35,102.36 38.96,103.76 38.96,117.86 36.16,120.65 36.16,129.67 43.02,136.53 43.02,154.31 44.8,156.08 49.5,156.08 49.75,156.34 49.75,160.15 C9.2 50.64,161.04 50.64,161.42 51.78,162.56 54.58,162.56 57.12,165.1 57.12,166.62 CN2.29
  BOTTOM w0.127: v1(61.28,102.87) 61,103.15 61,108.66 62.2,109.86 62.2,111.07 63.12,111.99
NETC10_2: length 174.9
  TOP w0.127: R17.1 C10.2 59.1,160.22 59.1,161.11 59.79,161.8 v1(60.55,161.8) ; v1(79.72,105.41) 79.98,105.16 84.14,105.16 86.05,103.25 92.17,103.25 97.89,97.54 112.11,97.54 v1(112.29,97.36)
  BOTTOM w0.127: v1(112.29,97.36) 112.31,97.36 113.96,99.01 113.96,114.71 113.66,115.01 113.66,127 115.11,128.45 115.11,135.23 117.21,137.34 117.21,140.23 117.19,140.26 117.19,140.67 117.21,140.69 117.21,143.1 117.93,143.81 117.93,153.06 115.64,155.35 108.65,155.35 106.94,157.06 106.94,162.9 103.85,165.99 98.39,165.99 96.62,164.21 83.41,164.21 81.95,162.75 80.3,162.75 79.34,161.8 v1(60.55,161.8) ; 77.9,112.26 77.9,110.11 78.71,109.3 78.71,106.43 v1(79.72,105.41)
NETC11_1: length 108.1
  TOP w0.127: R13.2 C11.1 R19.1 88.36,158.88 96.23,158.88 97.12,159.77 v1(103.09,159.77) ; v1(106.8,115.37) 106.62,115.19 103.35,115.19 102.58,114.43 102.58,112.14 101.44,111 95.95,111 95.35,111.61 92.58,111.61 91.41,112.78 91.41,113.92 92.42,114.94 92.42,123.19 88.74,126.87 84.93,126.87 84.68,127.13 83.92,127.13
  BOTTOM w0.127: v1(106.8,115.37) 107.66,116.23 107.66,125.86 107.79,125.98 107.79,126.75 108.05,127 108.05,136.53 110.28,138.76 110.28,150.44 109.14,151.59 107.64,151.59 103.09,156.14 v1(103.09,159.77)
NETC13_2: length 150.3
  TOP w0.127: C13.2 R10.1 80.61,161.29 v1(80.61,161.8) ; v1(79.85,106.43) 80.49,105.79 84.35,105.79 86.25,103.89 92.55,103.89 98.27,98.17 111.98,98.17 112.11,98.3 v1(112.13,98.3)
  BOTTOM w0.127: SB36.1 79.34,112.65 79.34,106.93 v1(79.85,106.43) ; v1(112.13,98.3) 112.24,98.3 113.33,99.39 113.33,114.43 112.95,114.81 112.95,127.18 114.47,128.7 114.47,135.51 116.55,137.59 116.55,143.36 117.29,144.09 117.29,152.78 115.36,154.71 108.27,154.71 106.22,156.76 106.22,162.6 103.47,165.35 98.77,165.35 97,163.58 83.79,163.58 82.01,161.8 v1(80.61,161.8)
NETC14_2: length 146.7
  TOP w0.127: C14.2 R11.1 83.28,161.67 v1(83.28,162.05) ; v1(112.06,99.14) 111.98,99.14 111.65,98.81 98.65,98.81 92.93,104.52 86.43,104.52 84.52,106.43 v1(80.87,106.43)
  BOTTOM w0.127: v1(80.87,106.43) 79.98,107.31 79.98,113.53 77.95,115.56 77.9,115.56 ; v1(112.06,99.14) 112.74,99.82 112.74,114.02 111.55,115.21 111.55,122.48 112.29,123.22 112.29,127.38 113.84,128.93 113.84,135.79 115.92,137.87 115.92,143.64 116.66,144.37 116.66,151.84 114.42,154.08 107.89,154.08 105.51,156.46 105.51,162.31 103.09,164.72 99.16,164.72 97.38,162.94 84.17,162.94 v1(83.28,162.05)
NETC15_1: length 131.9
  TOP w0.254: D1.B3 30.57,164.85 31.08,164.34 31.34,164.34 v1(31.46,164.47)
  TOP w0.381: v1(27.78,167) 28.29,167 28.84,167.56 CN1.1
  TOP w0.508: v1(21.43,143.51) 27.53,149.61 27.53,156.34 25.88,157.99 v1(25.88,159.38) 25.5,159.77 C15.1 23.33,159.77 U1.1 ; R108.2 48.86,100.71 47.19,99.03 47.19,95.73 46.25,94.79 34.97,94.79 34.13,95.63 34.13,97.31 30.86,100.58 15.34,100.58 14.45,101.47 v1(14.45,113.41) ; v1(27.78,167) R2.2 25.5,165.99 R1.1
  BOTTOM w0.508: v1(21.43,143.51) 21.43,143.1 18.89,140.56 18.89,137.21 18.26,136.58 18.26,122.56 15.84,120.14 15.84,114.81 v1(14.45,113.41) ; v1(31.46,164.47) 28.92,167 v1(27.78,167) 26.89,166.12 26.89,163.7 25.88,162.69 v1(25.88,159.38)
NETC16_2: length 95.9
  TOP w0.127: R15.1 53.18,158.5 C16.2 51.02,155.7 45.31,155.7 43.28,153.67 43.28,136.4 36.42,129.54 36.42,120.78 39.34,117.86 39.34,103.89 40.61,102.62 45.08,102.62 45.69,103.23 60.12,103.23 61.56,104.67 61.56,106.91 63.37,108.71 SB25.2
NETC17_1: length 218.2
  TOP w0.127: v1(84.04,118.36) 83.92,118.49 SB22.1 ; v1(87.09,69.09) 85.82,67.82 55.72,67.82 54.96,67.06 50.9,67.06 49.63,65.79 43.4,65.79 41.88,67.31 v1(41.88,68.96) ; v1(39.97,104.65) 39.59,105.03 39.59,117.98 36.67,120.9 36.67,129.41 43.53,136.27 43.53,153.27 45.46,155.19 54.32,155.19 55.47,156.34 C17.1 R16.2
  BOTTOM w0.127: v1(87.09,69.09) 92.81,74.8 92.81,85.09 92.23,85.66 85.76,85.66 84.17,87.25 84.17,94.36 85.44,95.63 85.44,101.09 87.22,102.87 87.22,113.54 83.66,117.09 83.66,117.98 v1(84.04,118.36) ; v1(39.97,104.65) 39.21,103.89 39.21,91.95 38.96,91.69 38.96,71.88 v1(41.88,68.96)
NETC23_2: length 14
  TOP w0.254: C23.2 17.18,151.31 U4.3 ; C23.2 16.99,151.38 v1(16.35,150.75) ; C23.2 17.69,151.96 U4.2 ; v1(22.83,149.73) 22.96,149.73 C28.1 23.8,150.66 U4.9
  BOTTOM w0.254: v1(16.35,150.75) 17.37,149.73 v1(22.83,149.73)
NETC24_2: length 17
  TOP w0.254: C24.2 3.65,151.26 v1(3.02,150.62) ; C24.2 4.48,151.96 U3.2 ; C24.2 4.54,151.26 4.54,151.31 U3.3 ; v1(11.78,150.62) C27.1 9.45,150.62 U3.9
  BOTTOM w0.254: v1(3.02,150.62) 4.21,149.43 10.59,149.43 v1(11.78,150.62)
NETC25_2: length 2.1
  TOP w0.127: C25.2 17.98,150.11 18.53,150.66 U4.4
NETC26_2: length 2.3
  TOP w0.127: C26.2 4.03,149.99 4.71,150.66 U3.4
NETC29_1: length 12.8
  TOP w0.127: C29.1 6.06,148.84 v1(6.45,148.84) 6.49,148.88 U3.5 ; U3.8 8.44,148.3 R27.1 7.33,147.19 R26.2 7.08,145.67 CN4.2
  BOTTOM w0.127: CN4.2 6.32,144.91 6.32,148.72 v1(6.45,148.84)
NETC30_1: length 7
  TOP w0.102: 96.87,147.05 97.25,146.67 99.07,146.67 99.45,147.05 U5.B5
  TOP w0.127: R28.2 C30.1 96.86,147.07 96.87,147.05
NETC34_2: length 1.8
  TOP w0.127: C34.2 SB4.1
NETC37_2: length 2.2
  TOP w0.127: 68.85,142.1 68.85,144.25 C37.2
NETC47_2: length 7.8
  TOP w0.127: C47.2 R72.1 85.44,120.4 80.99,120.4 R73.2
NETC52_2: length 14.6
  TOP w0.254: 70.33,115.82 70.25,115.9 U7.32
  TOP w0.508: 70.33,115.82 70.33,115.7 71.47,114.55 76.3,114.55 C53.1 77.82,113.03 C52.2 79.09,113.03 79.72,112.39 79.72,111.76 80.36,111.12 R92.2
NETC55_1: length 6.7
  TOP w0.203: 66.26,109.86 67.28,108.84 R95.2 67.41,107.95 69.69,105.66 X2.1
NETC56_1: length 6.8
  TOP w0.127: X1.2 57.02,107.47 57.02,109.63 C56.1 58.01,110.49 R87.1
NETC57_1: length 6.8
  TOP w0.127: R88.1 59.15,111.63 C57.1 59.79,109.6 59.79,107.94 X1.1
NETC62_1: length 2
  TOP w0.127: C62.1 102.86,102.77 U10.24
NETC62_2: length 3.2
  TOP w0.127: 102.71,101.98 103.37,101.32 103.37,100.43 103.63,100.17 U10.28
NETC63_1: length 1.9
  TOP w0.127: C63.1 113.25,101.47 U10.3
NETC64_1: length 2
  TOP w0.127: U10.1 112.91,100.17 C64.1
NETC64_2: length 1.9
  TOP w0.127: C64.2 113.27,100.82 U10.2
NETC65_1: length 5.2
  TOP w0.127: C65.1 105.38,99.44 105.76,99.82 105.76,100.53 105.47,100.82 U10.27
NETC67_1: length 7.1
  TOP w0.254: C67.1 9.49,95.5 7.08,95.5 R115.2 C68.2 6.16,94.59 U11.6
NETC73_1: length 55.7
  TOP w0.127: R122.2 C73.1 72.84,91.69 73.17,92.02 85.01,92.02 v1(85.19,92.2) ; v1(88.11,114.68) 88.11,115.06 89.63,116.59 89.63,120.4 89.38,120.65 80.49,120.65 R69.2
  BOTTOM w0.127: v1(88.11,114.68) 88.11,114.43 89.25,113.28 89.25,103.5 87.47,101.73 87.47,95 85.19,92.71 v1(85.19,92.2)
NETC77_1: length 1.9
  TOP w0.127: U14.9 81.36,86.75 C77.1
NETC77_2: length 2.2
  TOP w0.127: C77.2 R134.2 R130.2
NETC80_1: length 15.3
  TOP w0.508: D5.2 10.2,73.53 12.45,73.53 D6.2 D7.2 D8.2 18.91,73.51 19.27,73.15 C80.1 20.1,73.21 U20.1 22.16,73.21 22.73,72.64 22.73,71.78 22.26,71.31 U20.3
NETC82_1: length 1.7
  TOP w0.127: C82.1 23.9,70.54 U20.4
NETC102_1: length 6.7
  TOP w0.127: C102.1 76.17,37.59 76.17,36.2 78.73,33.63 U29.H8
NETC102_2: length 6.2
  TOP w0.127: C102.2 75.41,36.2 v1(76.55,35.05) ; U29.G8 v2(78.48,32.74)
  BOTTOM w0.127: v1(76.55,35.05) 77.31,35.05 78.48,33.88 v2(78.48,32.74)
NETC103_1: length 5.3
  TOP w0.127: C103.1 77.44,36.2 v1(77.44,35.69) ; U29.G7 v2(78.98,32.74)
  BOTTOM w0.127: v2(78.98,32.74) 78.98,34.14 v1(77.44,35.69)
NETC104_1: length 4.3
  TOP w0.127: C104.1 78.07,35.56 79.23,34.4 U29.H7
NETC105_1: length 65.4
  TOP w0.127: U29.G6 v2(79.48,32.74)
  TOP w0.203: CN20.4 117.8,35.64 117.8,39.65 115.03,42.42 112.87,42.42 111.22,40.77 109.57,40.77 102.46,33.66 98.14,33.66 95.65,36.14 95.65,38.56 92.3,41.91 81.38,41.91 79.72,40.26 79.72,37.21 79.22,36.7 v1(79.22,35.81)
  BOTTOM w0.127: v2(79.48,32.74) 79.48,35.55 v1(79.22,35.81)
NETC105_2: length 1.1
  TOP w0.127: R195.1 C105.2
NETC106_1: length 48
  TOP w0.203: U29.H6 79.96,33.22 79.96,36.31 80.36,36.7 80.36,36.83 80.99,37.47 80.99,38.99 83.41,41.4 91.92,41.4 95.02,38.3 95.02,36.02 97.89,33.15 102.71,33.15 109.76,40.19 CN20.6
NETC106_2: length 1.1
  TOP w0.127: R196.1 C106.2
NETC108_1: length 7.1
  TOP w0.127: C108.1 75.91,34.42 v1(76.55,34.42)
  TOP w0.203: U29.E6 v2(79.48,31.74)
  BOTTOM w0.127: v1(76.55,34.42) 77.31,34.42 78.07,33.66 78.07,32.64 78.45,32.26 78.96,32.26 79.48,31.74 v2(79.48,31.74)
NETC110_1: length 4.1
  TOP w0.127: U29.F1 82.97,31.99 83.47,32.49 83.89,32.49 C110.1
NETC113_1: length 12.6
  TOP w0.508: v1(97,33.15) C113.1 95.35,33.91 C115.2 93.57,33.27 L3.1
  BOTTOM w0.508: CN19.22 101.26,36.4 100.11,35.25 100.11,34.11 99.41,33.4 97.38,33.4 97.12,33.15 v1(97,33.15)
NETC114_1: length 7.8
  TOP w0.508: 29.62,35.46 U26.1 ; U26.1 30.99,35.46 ; U26.1 30.31,34.38 ; U26.1 30.31,36.54 ; C114.1 29.81,33.48 ; C114.1 30.27,33.02 ; C114.1 29.36,33.02 ; 30.77,32.89 R207.1 31.34,33.48 ; R209.2 28.42,33.72 ; R209.2 27.83,33.15 ; R209.2 29,33.15
NETC117_2: length 8.8
  TOP w0.127: 68.42,28.8 68.42,29.46 v1(69.37,30.42) 69.37,30.92 C117.2
  BOTTOM w0.127: CN23.1 73.63,29.59 72.8,30.42 v1(69.37,30.42)
NETC122_1: length 3.8
  TOP w0.127: C122.1 75.79,29.84 76.93,30.99 U29.D9
NETC124_1: length 24.7
  TOP w0.508: 20.24,32.38 Z1.2 ; Z1.2 22.61,32.38 ; Z1.2 21.43,31.37 ; Z1.2 21.43,33.4 ; 18.26,25.14 U31.3 ; U31.3 18.9,25.62 ; U31.3 18.26,26.1 ; C124.1 19.02,29.67 ; C124.1 19.02,28.75 ; C124.1 19.48,29.21
  TOP w1.143: L2.1 6.89,31.66 9.9,34.67 20.54,34.67
NETC124_2: length 26
  TOP w0.508: L2.2 10.65,31.66 ; L2.2 8.32,31.66 ; L2.2 9.49,30.49 ; L2.2 9.49,32.83 ; Z1.1 18.81,32.38 ; Z1.1 17.63,31.37 ; Z1.1 16.44,32.38 ; Z1.1 17.63,33.4 ; 16.99,25.14 U31.2 ; U31.2 16.99,26.1 ; U31.2 16.34,25.62 ; CN22.2 9.82,16.59 ; CN22.2 7.54,17.78 ; CN22.2 5.25,16.59 ; CN22.2 7.54,15.4 ; C124.2 18,29.67 ; C124.2 17.54,29.21 ; C124.2 18,28.75 ; CN22.3 4.44,23.88 ; CN22.3 3.24,21.59 ; CN22.3 4.44,19.3 ; CN22.3 5.63,21.59
NETC125_2: length 5
  TOP w0.127: U29.C9 77.88,30.49 75.53,28.14 75.53,27.69 C125.2
NETC127_2: length 89.8
  TOP w0.127: U29.A7 78.7,28.96 78.47,28.96 77.44,27.92 C127.2 v1(76.52,26.29)
  BOTTOM w0.127: v1(76.52,26.29) 74.97,27.84 74.97,29.13 73.37,30.73 70.2,30.73 69.06,31.88 56.66,31.88 42.39,46.15 42.39,62.23 35.78,68.83 29.81,68.83 25.55,73.1 25.55,76.78 JP16.1
NETC128_2: length 4
  TOP w0.127: v1(79.07,27.3) 79.07,27.3 79.07,26.4 C128.2 ; U29.B6 v2(79.48,29.74)
  BOTTOM w0.127: v1(79.07,27.3) 79.07,27.3 79.34,27.57 79.34,29.6 v2(79.48,29.74)
NETC129_1: length 2.7
  TOP w0.381: R227.2 C129.1 R226.2
NETC129_2: length 4.5
  TOP w0.229: v2(80.98,29.74) 80.98,29.74 81.23,29.99 U29.B3
  TOP w0.508: C129.2 v1(81.63,27.3)
  BOTTOM w0.381: v2(80.98,29.74) 80.93,29.69 80.93,29.65 80.49,29.21 80.49,28.45 v1(81.63,27.3)
NETC130_1: length 2.2
  TOP w0.203: C130.1 R224.2 R225.1
NETC130_2: length 5.9
  TOP w0.203: U29.A2 81.76,29.49 81.88,29.36 81.88,28.45 84.8,25.53 C130.2
NETC136_1: length 7.8
  TOP w0.127: v1(62.58,17.78) 62.07,18.29 U30.7 ; C136.1 v1(58.26,16.13)
  BOTTOM w0.127: v1(58.26,16.13) 59.91,17.78 v1(62.58,17.78)
NETC136_2: length 2.1
  TOP w0.127: U30.5 59.53,17.27 C136.2
NETC137_1: length 2.1
  TOP w0.127: C137.1 63.34,17.27 63.34,19.21
NETC139_1: length 171.5
  TOP w0.127: U36.1 11.8,13 12.44,13.64 13,13.64 C142.1 v1(14.62,12.95) ; U35.1 97.57,15.54 98.19,16.15 99,16.15 C139.1 99.54,15.88 99.54,16.99 99.26,17.27 R238.2 96.39,18.01 94.81,18.01 93.19,16.38 v1(93.19,15.16)
  BOTTOM w0.127: v1(93.19,15.16) 88.94,10.92 29.81,10.92 26.94,8.05 18.89,8.05 14.62,12.32 v1(14.62,12.95) 14.62,21.01 27.27,33.66 27.27,67.39 22.57,72.09 JP16.2
NETC144_1: length 5.6
  TOP w0.127: U15.3 42.89,89.3 42.64,89.55 42.64,90.3 42.39,90.55 C144.1 R124.1 R128.2
NETCN1_4: length 8.5
  TOP w0.127: v1(31.59,165.35) 31.09,164.85 D1.A3 ; CN1.4 30.79,167.17 31.08,166.88 33.12,166.88 R5.1 33.37,165.35 v1(33.24,165.35)
  BOTTOM w0.127: v1(33.24,165.35) v1(31.59,165.35)
NETCN2_3: length 56.9
  BOTTOM w0.127: CN2.3 90.01,169.29 88.36,169.29 87.47,168.4 87.47,167.13 87.09,166.75 82.77,166.75 82.39,166.37 82.39,164.97 81.5,164.08 80.23,164.08 78.84,162.69 57.88,162.69 57.12,161.93 57.12,160.81 58.01,159.92 58.01,147.27 58.87,146.41 58.87,145.95 SB27.1
NETCN2_5: length 112.1
  TOP w0.127: v1(108.53,116.38) 108.48,116.38 107,114.91 103.91,114.91 103.12,114.12 103.12,112.17 101.7,110.74 94.71,110.74 94.58,110.62 92.81,110.62 90.14,113.28 90.14,115.19 90.9,115.95 90.9,121.41 89.12,123.19 84.17,123.19 SB19.1 ; v1(110.71,138.18) 110.84,138.18 111.25,138.58 111.25,152.76 109.77,154.23 108.96,154.23 107.18,156.01 107.18,165.4 v1(105.68,166.9)
  BOTTOM w0.127: v1(108.53,116.38) 108.55,116.38 108.81,116.64 108.81,126.75 108.55,127 108.55,136.14 109.57,137.16 110.46,137.16 110.71,137.41 v1(110.71,138.18) ; CN2.5 89.86,166.9 v1(105.68,166.9)
NETCN2_7: length 56.2
  BOTTOM w0.127: 57.55,142.13 57.25,142.43 57.25,159.31 56.36,160.2 56.36,162.31 57.41,163.36 76.28,163.36 77.59,164.67 77.59,168.38 78.38,169.16 85.06,169.16 CN2.7
NETCN2_9: length 87
  TOP w0.127: v1(103.45,161.85) 102.97,162.33 102.97,164.87 98.7,169.14 85.03,169.14 CN2.9 ; 87.34,128.14 88.74,128.14 90.52,129.92 90.52,132.59 91.54,133.6 91.54,136.91 92.55,137.92 98.9,137.92 99.41,137.41 101.7,137.41 103.35,135.76 108.81,135.76 v1(109.06,135.51)
  BOTTOM w0.127: v1(109.06,135.51) 109.06,135.76 110.2,136.91 110.77,136.91 111.27,137.4 111.27,139.05 111.07,139.25 111.07,150.91 109.83,152.15 107.73,152.15 106.46,153.42 106.45,153.42 103.65,156.21 103.65,161.65 v1(103.45,161.85)
NETCN2_11: length 45.4
  BOTTOM w0.127: SB28.1 57.63,145.8 57.63,159.61 56.74,160.5 56.74,162.18 57.63,163.07 78.45,163.07 80.11,164.72 80.11,166.75 CN2.11
NETCN2_13: length 95.5
  TOP w0.127: 84.05,129.42 84.18,129.42 84.93,130.18 88.61,130.18 89.12,130.68 89.12,133.73 90.94,135.55 90.94,136.87 92.25,138.18 99.16,138.18 99.66,137.67 101.82,137.67 103.47,136.02 109.44,136.02 v1(109.95,135.51) ; v1(103.55,163.04) 103.55,164.8 98.83,169.52 80.33,169.52 CN2.13
  BOTTOM w0.127: v1(109.95,135.51) 109.95,136.14 110.33,136.53 110.79,136.53 111.6,137.34 111.6,139.12 111.35,139.37 111.35,151.03 109.95,152.43 107.84,152.43 104.01,156.26 104.01,162.59 v1(103.55,163.04)
NETCN2_14: length 8.6
  TOP w0.127: CN2.14 79.98,164.08 82.52,164.08 R13.1
NETCN2_15: length 10.4
  TOP w0.127: CN2.15 77.44,166.62 77.44,164.72 78.96,163.19 80.23,163.19 R11.2
NETCN2_17: length 9.6
  TOP w0.127: CN2.17 75.03,166.5 75.03,164.97 78.45,161.54 78.84,161.54 R10.2
NETCN2_19: length 18.5
  TOP w0.127: R17.2 56.86,161.54 58.13,162.81 67.72,162.81 70.07,165.16 70.07,166.88 CN2.19
NETCN2_21: length 48.8
  TOP w0.127: 63.83,142.14 63.83,142.79 v1(63.65,142.98)
  BOTTOM w0.127: v1(63.65,142.98) 63.57,143.05 62.38,143.05 59.66,140.34 58.06,140.34 54.96,143.43 54.96,147.07 56.38,148.49 56.38,158.83 55.34,159.87 55.34,162.56 56.86,164.08 66.77,164.08 67.23,164.54 67.23,166.57 CN2.21
NETCN2_23: length 103.7
  TOP w0.127: v1(103.14,160.6) 104.08,161.54 104.08,164.85 99.03,169.9 68.01,169.9 CN2.23 ; SB11.1 84.07,131.47 84.07,131.85 90.9,138.68 99.54,138.68 100.04,138.18 102.08,138.18 103.47,136.78 v1(107.03,136.78)
  BOTTOM w0.127: v1(103.14,160.6) 102.58,160.05 102.58,156.29 103.45,155.42 103.45,154.46 103.96,153.95 103.96,153.03 105.18,151.82 106.82,151.82 107.31,151.33 109.01,151.33 110.03,150.32 110.03,139.9 107.92,137.79 107.92,137.41 107.28,136.78 v1(107.03,136.78)
NETCN2_24: length 26.9
  TOP w0.127: R7.1 45.82,164.08 53.69,164.08 54.45,164.85 54.45,168.28 55.21,169.04 61.31,169.04 61.94,168.4 61.94,167.64 62.83,166.75 64.61,166.75 CN2.24
NETCN2_26: length 9.8
  TOP w0.127: R16.1 58.26,163.7 61.82,163.7 CN2.26
NETCN2_27: length 10.9
  TOP w0.127: CN2.27 59.63,166.6 59.63,164.72 59.02,164.11 57.14,164.11 55.34,162.31 55.34,162.18 R15.2
NETCN2_32: length 8.9
  TOP w0.127: R12.1 51.28,163.19 54.32,163.19 55.85,164.72 CN2.32
NETCN3_4: length 161.8
  TOP w0.127: v1(103.6,42.16) 103.6,55.5 106.78,58.67 112.54,58.67 118,64.14 v1(118,64.21) ; U33.12 84.28,20.81 84.68,21.21 85.57,21.21 v1(86.2,20.57) ; CN3.4 v1(118.71,151.16)
  BOTTOM w0.127: v1(118,64.21) 118,70.38 118.99,71.37 118.99,90.68 115.03,94.64 115.03,125.98 118.89,129.84 118.89,150.98 v1(118.71,151.16) ; v1(103.6,42.16) 102.46,41.02 92.93,41.02 89.76,37.85 89.76,28.19 90.14,27.81 90.14,24.89 87.85,22.61 87.85,21.59 86.84,20.57 v1(86.2,20.57)
NETCN3_8: length 3.7
  TOP w0.127: v1(113.63,150.44) CN3.8
  BOTTOM w0.127: SB43.1 v1(113.63,150.44)
NETCN4_1: length 7.4
  TOP w0.127: CN4.1 4.67,145.8 5.81,145.8 6.45,146.43 6.45,147.57 R26.1 7.14,148.26 U3.6
NETCN5_2: length 18.5
  TOP w0.127: JP6.2 19.27,132.08 U8.6 19.27,125.86 18.76,125.35 15.84,125.35 15.27,125.92 D2.2 14.66,127.34 13.81,126.49 11.53,126.49 CN5.2
NETCN5_5: length 4
  TOP w0.127: R77.2 12.49,119.56 CN5.5
NETCN5_7: length 19.8
  TOP w0.127: R55.1 U8.7 18,125.98 17.75,125.73 16.35,125.73 15.97,126.11 15.97,128.14 15.59,128.52 13.81,128.52 13.37,128.08 D2.1 12.08,127.34 11.78,127.64 11.78,128.4 11.02,129.16 9.49,129.16 7.37,127.03 CN5.7
NETCN5_9: length 6.8
  TOP w0.127: CN5.9 12.62,120.95 R70.2
NETCN6_2: length 5.4
  TOP w0.127: CN6.2 R44.2
NETCN6_30: length 6.3
  TOP w0.127: 36.93,116.46 35.15,116.46 32.73,118.87 CN6.30
NETCN7_24: length 50.2
  TOP w0.127: CN7.24 v1(98.27,122.68)
  BOTTOM w0.127: v1(98.27,122.68) 97.63,122.05 96.23,122.05 95.6,122.68 90.39,122.68 88.49,124.59 67.91,124.59 65.88,126.62 63.34,126.62 61.69,124.97 61.69,124.49 59.15,121.95 59.15,119 58.52,118.36 SB33.2
NETCN7_25: length 52.6
  TOP w0.127: CN7.25 v1(97,121.41)
  BOTTOM w0.127: SB41.2 58.64,113.84 58.9,114.1 58.9,114.81 59.53,115.44 59.53,121.95 63.82,126.24 65.75,126.24 67.66,124.33 88.11,124.33 90.14,122.3 94.84,122.3 95.73,121.41 v1(97,121.41)
NETCN7_32: length 6.5
  TOP w0.127: CN7.32 101.31,117.6 102.58,116.33 R79.2
NETCN7_33: length 44.5
  TOP w0.102: SB23.2 67.79,113.79
  TOP w0.127: CN7.33 96.29,116.33 v1(96.72,116.76) ; 67.79,113.79 v1(66.52,115.06)
  BOTTOM w0.127: v1(96.72,116.76) 96.18,116.76 92.93,120.02 88.87,120.02 86.33,122.56 67.79,122.56 66.64,121.41 66.64,118.75 65.63,117.73 65.63,115.95 v1(66.52,115.06)
NETCN7_34: length 46.6
  TOP w0.127: CN7.34 99.13,116.33 98.06,117.4 v1(98.06,117.7) ; v1(65.88,114.17) 65.88,113.54 SB24.2
  BOTTOM w0.127: v1(98.06,117.7) 97.61,117.25 96.08,117.25 93.06,120.27 89.12,120.27 86.58,122.81 67.66,122.81 66.39,121.54 66.39,118.87 65.37,117.86 65.37,115.32 65.88,114.81 v1(65.88,114.17)
NETCN8_2: length 3.5
  TOP w0.127: R72.2 84.55,117.86 CN8.2
NETCN9_2: length 9
  TOP w0.127: CN9.2 115.31,108.86 114.9,108.46 114.9,105.69 112.63,103.42 U10.6
NETCN9_3: length 9.3
  TOP w0.127: U10.10 113,106.02 113.38,106.4 113.38,109.6 115.41,111.63 CN9.3
NETCN9_6: length 10.8
  TOP w0.127: U10.5 112.62,102.77 115.28,105.44 115.28,107.06 115.69,107.47 CN9.6
NETCN9_7: length 11.8
  TOP w0.127: CN9.7 119.48,110.36 115.03,110.36 114.01,109.35 114.01,106.22 113.16,105.37 U10.9
NETCN9_8: length 18.7
  TOP w0.127: U10.7 111.73,104.06 112.77,104.06 114.52,105.82 114.52,109.22 115.41,110.11 117.7,110.11 118.71,109.09 120.62,109.09 121.25,109.73 121.25,111.35 CN9.8
NETCN10_1: length 3.5
  TOP w0.508: R92.1 85.57,111.12 CN10.1
NETCN11_4: length 99.8
  TOP w0.127: 35.56,98.42 32.77,101.22 16.35,101.22 15.84,101.73 v1(15.21,101.73) ; v1(25.47,47.78) 22.09,47.78 17.88,43.56 16.48,43.56 15.08,42.16 12.03,42.16 11.53,41.66 R194.1
  BOTTOM w0.127: v1(15.21,101.73) 15.21,98.17 15.84,97.54 15.84,89.15 18.76,86.23 18.76,76.2 20.57,74.4 20.57,72.14 25.65,67.06 25.65,49.12 26,48.77 26,48.23 25.55,47.78 v1(25.47,47.78)
NETCN11_6: length 83.4
  TOP w0.127: v1(25.75,101.73) 34.8,101.73 38.1,98.42 ; v1(27.53,158.62) 28.16,158.62 R5.2
  BOTTOM w0.127: v1(27.53,158.62) 26.13,157.23 26.13,142.37 24.45,140.69 24.45,133.68 23.36,132.59 23.36,129.79 25.8,127.36 25.8,124.13 25.37,123.7 25.37,111 26.6,109.77 26.6,102.34 25.98,101.73 v1(25.75,101.73)
NETCN11_8: length 43.5
  TOP w0.127: R75.2 15.08,116.71 15.08,103 15.84,102.23 36.83,102.23 40.64,98.42
NETCN11_10: length 124.8
  TOP w0.127: R265.2 123.13,135.1 119.3,135.1 118.15,136.25 v1(117.98,136.25) ; v1(113.25,97.36) 112.62,96.72 111.96,96.72 111.48,97.21 97.5,97.21 92.5,102.21 91.66,102.21 91.36,101.9 85.64,101.9 84.2,103.35 74.31,103.35 72.59,101.63 64.05,101.63 63.19,102.49 62.47,102.49 61.79,101.8 60.5,101.8 60.12,102.18 48.23,102.18 45.69,99.64 44.4,99.64 43.18,98.42
  BOTTOM w0.127: v1(117.98,136.25) 117.01,136.25 116.02,135.25 116.02,128.14 114.42,126.54 114.42,98.5 113.28,97.36 v1(113.25,97.36)
NETCN11_12: length 125.2
  TOP w0.127: v1(113.1,96.19) 112.13,96.19 111.37,96.95 97.3,96.95 92.37,101.88 91.74,101.88 91.41,101.55 85.39,101.55 84.02,102.92 74.64,102.92 72.89,101.17 64.13,101.17 63.06,102.23 62.58,102.23 61.89,101.55 60.39,101.55 60.01,101.93 48.76,101.93 45.72,98.89 45.72,98.42 ; R266.2 124.73,136.73 124.73,135.31 124.23,134.8 119.17,134.8 118.43,135.53 v1(117.98,135.53)
  BOTTOM w0.127: v1(117.98,135.53) 118.48,135.03 118.48,130.05 114.73,126.29 114.73,97.82 v1(113.1,96.19)
NETCN11_16: length 59
  TOP w0.127: 50.8,98.42 49.24,96.87 49.24,95.63 48.61,95 47.85,95 46.83,93.98 30.45,93.98 28.54,92.08 17.88,92.08 17.49,92.46 15.46,92.46 8.48,85.47 8.48,83.69 8.1,83.31 4.67,83.31 4.16,82.8 4.16,80.66 4.47,80.35 4.47,80.33 CN13.4
NETCN11_18: length 59.5
  TOP w0.127: R108.1 53.34,100.62 53.34,98.42 52.37,97.46 50.21,97.46 49.5,96.75 49.5,95.25 48.99,94.74 47.97,94.74 46.96,93.73 30.83,93.73 28.8,91.69 17.75,91.69 17.37,92.08 15.72,92.08 8.99,85.34 8.99,83.44 7.59,82.04 CN13.6
NETCN11_20: length 127
  TOP w0.127: v1(58.39,41.78) 57.88,41.78 53.94,37.85 53.94,31.24 52.8,30.1 52.8,18.03 56.23,14.61 58.52,14.61 59.28,13.84 59.28,8.59 59.76,8.1 v1(59.84,8.1) ; R109.1 55.88,100.11 55.88,98.42
  BOTTOM w0.127: v1(59.84,8.1) 59.84,4.67 62.73,1.78 68.91,1.78 CN23.6 ; v1(58.39,41.78) 58.13,42.04 58.13,44.32 61.54,47.73 61.54,59.26 62.55,60.27 62.55,63.86 61.97,64.44 61.97,65.53 60.52,66.98 60.52,71.86 59.46,72.92 57.96,72.92 57.12,72.09 56.03,72.09 55.57,72.54 55.57,73.76 56.23,74.42 56.23,77.22 56.74,77.72 56.74,84.71 55.09,86.36 55.09,91.82 56.99,93.73 56.99,97.31 55.88,98.42
NETCN11_24: length 80.1
  TOP w0.127: R76.1 19.53,117.35 v1(19.53,112.78) ; v1(15.34,91.06) 15.46,90.93 30.58,90.93 32.61,92.96 47.34,92.96 48.23,93.85 51.15,93.85 51.91,94.61 53.69,94.61 54.07,95 58.9,95 59.66,95.76 59.66,96.9 60.96,98.2 60.96,98.42
  BOTTOM w0.127: v1(15.34,91.06) 15.34,97.41 14.07,98.68 14.07,106.55 19.53,112.01 v1(19.53,112.78)
NETCN11_26: length 78.7
  TOP w0.127: 63.5,98.42 64.48,97.44 64.48,95.53 63.7,94.74 59.91,94.74 59.4,94.23 54.45,94.23 54.07,93.85 52.29,93.85 51.53,93.09 49.12,93.09 48.48,92.46 33.04,92.46 30.75,90.17 15.08,90.17 10.13,85.22 10.13,82.3 5.94,78.11 2.64,78.11 1.87,78.87 1.87,81.15 CN13.5
NETCN11_28: length 159.9
  TOP w0.127: U4.10 23.27,151.31 v1(23.59,151.64) 23.27,151.96 U4.11 ; U3.11 9.93,151.96 v1(10.26,151.64) 9.93,151.31 U3.10 ; 66.04,98.42 66.01,98.42 65.12,97.54 65.12,95.25 64.1,94.23 60.19,94.23 59.68,93.73 54.83,93.73 54.45,93.34 52.55,93.34 51.78,92.58 49.37,92.58 48.74,91.95 33.5,91.95 30.5,88.95 27.6,88.95 26.77,89.79 17.37,89.79 v1(17.24,89.66) ; U4.14 v1(20.99,154.43) ; U3.14 v1(7.79,154.38)
  BOTTOM w0.127: JP14.3 19.27,83.06 19.27,86.61 17.24,88.65 v1(17.24,89.66) 16.61,90.3 16.61,92.33 16.8,92.52 16.8,101.66 15.59,102.87 15.59,105.47 16.8,106.68 16.8,108.24 20.16,111.6 20.16,111.76 23.34,114.94 23.34,125.73 21.99,127.08 21.99,141.78 24.61,144.4 24.61,150.62 v1(23.59,151.64) 20.99,154.23 v1(20.99,154.43) 19.22,156.21 8.48,156.21 7.84,155.57 7.84,154.43 v1(7.79,154.38) 8.48,153.69 8.48,153.67 10.26,151.89 v1(10.26,151.64)
NETCN11_30: length 186
  TOP w0.127: v1(96.49,40.51) 95.68,41.33 95.68,42.88 82.06,56.49 81.02,56.49 79.52,57.99 71.16,57.99 70.66,57.48 67.46,57.48 66.9,58.04 v1(66.77,58.04) ; R256.1 v1(23.08,10.16)
  BOTTOM w0.127: 68.58,98.42 68.58,97.63 69.82,96.39 69.82,94.87 74.39,90.3 74.39,82.91 74.85,82.45 74.85,76.02 73.6,74.78 73.6,71.27 69.26,66.93 69.26,62.26 66.95,59.94 66.95,58.22 v1(66.77,58.04) ; v1(96.49,40.51) 93.19,40.51 91.28,38.61 91.28,31.88 90.52,31.11 90.52,28.57 91.03,28.07 91.03,22.23 90.14,21.34 90.14,14.86 87.85,12.57 29.94,12.57 26.38,9.02 24.23,9.02 v1(23.08,10.16)
NETCN11_32: length 256
  TOP w0.127: v1(116.02,70.59) 115.97,70.59 115.82,70.43 83.74,70.43 82.39,69.09 73.5,69.09 v1(72.99,69.6) ; v1(76.68,9.91) 76.68,14.48 73.88,17.27 73.88,24.18 76.04,26.34 76.04,27.18 78.23,29.37 U29.A9 ; v1(12.85,11.07) 12.85,11.13 11.82,12.15 U36.4 ; U35.4 97.57,14.69 v1(98.39,13.87)
  BOTTOM w0.127: v1(12.85,11.07) 12.85,11.35 13.28,11.79 14.09,11.79 18.66,7.21 27.76,7.21 30.7,10.16 75.41,10.16 75.66,9.91 v1(76.68,9.91) 77.57,9.91 77.82,10.16 90.04,10.16 92.63,12.75 97.28,12.75 v1(98.39,13.87) 98.39,14.43 103.73,19.76 103.73,40.51 111.98,48.77 111.98,57.66 114.5,60.17 114.5,69.06 v1(116.02,70.59) ; v1(72.99,69.6) 73.96,70.56 73.96,74.5 75.28,75.82 75.28,83.01 74.9,83.39 74.9,90.55 71.98,93.47 71.98,97.57 71.12,98.42
NETCN11_34: length 2.5
  TOP w0.508: 73.66,98.42 73.66,100.23 R111.2
NETCN11_38: length 2.6
  TOP w0.127: 78.74,98.42 78.74,100.74 R107.2
NETCN12_2: length 27.7
  TOP w0.127: R153.1 120.4,81.03 CN15.7 121.76,82.39 121.76,84.58 121.08,85.27 117.01,85.27 116.44,85.84 U17.1 116.44,87.41 115.97,87.88 115.06,87.88 v1(114.55,87.38) ; CN12.2 108.45,87.5 109.29,88.34 v1(109.52,88.34) 109.74,88.12 RS1.14
  BOTTOM w0.127: v1(109.52,88.34) 109.82,88.04 111.02,88.04 112.59,86.46 113.63,86.46 v1(114.55,87.38)
NETCN12_4: length 24.4
  TOP w0.127: CN12.4 108.55,86.23 109.06,86.74 109.06,87.15 v1(109.57,87.66) 110.67,87.66 110.7,87.63 RS1.12 ; v1(115.79,78.49) 115.79,78.61 R155.2 120.14,79.25 CN15.9 ; v1(114.5,85.5) 114.75,85.5 115.14,85.89 U17.3
  BOTTOM w0.127: v1(109.57,87.66) 110.97,87.66 112.44,86.18 113.81,86.18 v1(114.5,85.5) 114.5,84.79 116.17,83.11 116.17,78.87 v1(115.79,78.49)
NETCN12_6: length 30
  TOP w0.127: RS1.10 109.93,87.12 v1(109.53,86.72) 109.14,86.32 109.14,86.23 109.11,86.21 109.11,85.47 108.6,84.96 CN12.6 ; v1(114.01,75.18) 115.67,75.18 R160.1 R162.2 119.89,72.9 CN15.13 ; U17.4 115.14,83.93 114.9,83.69 v1(114.14,83.69)
  BOTTOM w0.127: v1(114.01,75.18) 114.7,75.87 114.7,83.13 v1(114.14,83.69) 113.68,83.69 110.66,86.72 v1(109.53,86.72)
NETCN12_8: length 20.2
  TOP w0.127: RS1.8 110.18,86.62 109.82,86.26 109.54,86.26 109.37,86.08 109.37,84.51 v1(109.25,84.39) 108.55,83.69 CN12.8 ; v1(114.01,81.79) 114.27,82.04 115.67,82.04 R152.1 116.44,82.82 U17.5 120.03,84.44 CN15.5
  BOTTOM w0.127: v1(109.25,84.39) 111.86,81.79 v1(114.01,81.79)
NETCN12_10: length 29.1
  TOP w0.127: CN15.15 111.42,71.12 v1(111.14,71.4) ; CN12.10 v1(109.44,82.42) 110.08,82.42 110.57,82.92 U18.3 110.57,83.86 109.95,84.48 109.95,85.19 110.38,85.62 RS1.4
  BOTTOM w0.127: v1(111.14,71.4) 112.24,72.49 112.24,79.63 v1(109.44,82.42)
NETCN12_12: length 118.4
  TOP w0.127: CN12.12 109.32,81.15 109.69,81.52 U18.4 111.08,81.04 111.6,80.52 112.49,80.52 113.25,79.76 113.25,73.15 112.26,72.16 88.33,72.16 85.95,74.55 61.11,74.55 60.29,73.74 55.9,73.74 55.57,73.41 52.9,73.41 52.39,72.9 50.79,72.9 50.23,72.34 v1(50.21,72.34) ; SB26.2 49.75,107.7 v1(49.88,107.57)
  BOTTOM w0.127: v1(50.21,72.34) 50.21,75.13 51.94,76.86 51.94,82.91 49.88,84.96 49.88,92.23 51.94,94.28 51.94,105.51 v1(49.88,107.57)

# Allegro board MB1144.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PF6: length 54.4
  TOP w0.127: R105.2 60.55,113.79 61.56,114.81 62.2,114.81 v1(62.45,115.06) 62.58,115.19 62.83,115.19 63.25,115.61 U7.18 ; CN7.27 v1(97.12,120.14)
  BOTTOM w0.127: v1(97.12,120.14) 96.11,120.14 94.33,121.92 90.01,121.92 87.85,124.08 66.64,124.08 64.97,122.4 64.97,119.86 62.2,117.09 62.2,115.44 62.45,115.19 v1(62.45,115.06)
PF7: length 55.8
  TOP w0.127: CN7.28 98.27,120.14 v1(98.14,120.02) ; U7.19 63.75,115.72 62.83,114.81 v1(62.83,114.55) 62.71,114.43 61.56,114.43 60.93,113.79 60.93,111.12 R106.2
  BOTTOM w0.127: v1(62.83,114.55) 62.83,114.68 63.34,115.19 63.34,117.73 65.25,119.63 65.25,122.17 66.9,123.83 87.6,123.83 89.88,121.54 94.08,121.54 95.98,119.63 97.76,119.63 v1(98.14,120.02)
PF8: length 50.1
  TOP w0.127: U7.20 64.25,115.84 v1(64.23,115.82) 63.34,114.94 63.34,114.43 62.96,114.05 61.82,114.05 61.56,113.79 R89.2 ; v1(98.27,118.87) CN7.30
  BOTTOM w0.127: v1(98.27,118.87) 98.01,118.87 97.38,118.24 96.11,118.24 93.57,120.78 89.63,120.78 87.09,123.32 67.28,123.32 65.81,121.84 65.81,119.18 64.23,117.6 v1(64.23,115.82)
PF9: length 52.3
  TOP w0.127: CN7.29 v1(96.87,118.87) ; U7.21 64.75,115.71 v1(64.23,115.19) 64.1,115.19 63.6,114.68 63.6,113.54 R90.2 62.96,113.28 62.58,112.9 62.58,111 63.09,110.49
  BOTTOM w0.127: v1(96.87,118.87) 96.11,118.87 93.82,121.16 89.76,121.16 87.34,123.57 67.02,123.57 65.5,122.05 65.5,119.38 63.72,117.6 63.72,115.7 v1(64.23,115.19)
PF10: length 49.7
  TOP w0.127: R91.2 v1(64.74,114.68) 64.74,115.06 65.25,115.57 U7.22 ; v1(96.84,117.75) 96.69,117.6 CN7.31
  BOTTOM w0.127: SB37.1 v1(64.74,114.68) 64.74,117.6 66.11,118.97 66.11,121.64 67.53,123.06 86.84,123.06 89.38,120.52 93.31,120.52 96.08,117.75 v1(96.84,117.75)
PF11: length 156.9
  TOP w0.127: v1(96.87,125.22) CN7.19 93.41,125.22 92.98,124.79 92.98,114.73 92.42,114.17 92.42,113.16 v1(92.04,112.78) ; v1(91.97,101.37) 91.79,101.19 84.83,101.19 83.64,102.39 74.59,102.39 72.21,100 62.73,100 62.33,99.59 62.33,95.61 61.72,95 59.76,95 59.25,94.49 54.32,94.49 53.94,94.11 52.17,94.11 51.4,93.34 48.99,93.34 48.36,92.71 32.84,92.71 30.68,90.55 14.7,90.55 9.62,85.47 9.62,82.42 5.68,78.49 3.78,78.49 CN13.3 ; v1(75.53,126.11) 75.53,125.86 75.32,125.65 U7.49
  BOTTOM w0.127: v1(92.04,112.78) 92.3,112.52 92.3,111 93.29,110.01 93.29,103.5 92.65,102.87 92.65,102.06 v1(91.97,101.37) ; v1(75.53,126.11) 76.04,126.62 90.27,126.62 91.66,125.22 v1(96.87,125.22)
PG6: length 45.8
  TOP w0.127: R35.2 64.36,143.23 64.66,142.93 64.66,142.39 ; CN6.3 28.04,135.38 28.82,134.59 v1(28.92,134.59) ; 64.81,142.12 64.81,141.68 63.72,140.59 v1(63.47,140.59) 63.25,140.37 U7.91
  BOTTOM w0.127: v1(28.92,134.59) 29.25,134.26 29.89,134.26 33.98,138.35 55.26,138.35 55.59,138.68 61.69,138.68 63.47,140.46 v1(63.47,140.59)
PG7: length 42.8
  TOP w0.127: R34.2 62.6,143.41 62.6,140.86 v1(62.75,140.72) U7.92 ; CN6.4 30.52,135.38 29.91,134.77 v1(29.74,134.77)
  BOTTOM w0.127: v1(62.75,140.72) 62.75,140.25 61.56,139.06 55.34,139.06 55.01,138.73 33.85,138.73 29.89,134.77 v1(29.74,134.77)
PG8: length 176.5
  TOP w0.127: R158.2 17.75,76.45 v1(18.64,75.56) ; v1(28.16,131.06) 27.65,131.57 CN6.9 25.01,131.57 23.87,130.43 23.87,125.65 23.95,125.58 23.95,116.2 v1(22.8,115.06) ; v1(25.47,48.41) 25.5,48.39 29.94,48.39 31.97,46.35 47.21,46.35 51.28,42.29 55.47,42.29 57.5,44.32 R188.2 ; U7.93 62.25,138.1 61.06,136.91 v1(60.67,136.91)
  BOTTOM w0.127: v1(60.67,136.91) 59.66,136.91 58.01,135.25 37.18,135.25 32.48,130.56 28.67,130.56 v1(28.16,131.06) ; v1(22.8,115.06) 21.41,113.67 19.53,113.67 18.89,113.03 18.89,112.01 13.68,106.81 13.68,98.3 14.83,97.16 14.83,89.79 18.51,86.11 18.51,75.69 v1(18.64,75.56) 20.16,74.04 20.16,71.88 25.32,66.73 25.32,48.56 v1(25.47,48.41)
PG9: length 93.6
  TOP w0.127: CN6.20 v1(29.69,125.22) ; U7.124 51.13,129.65 v1(51.02,129.54) ; v1(76.8,143.38) 79.22,140.97 101.19,140.97 101.82,140.34 102.97,140.34 104.36,138.94 106.78,138.94 R43.2
  BOTTOM w0.127: v1(76.8,143.38) 76.8,142.16 73.68,139.04 72.79,139.04 65.96,132.21 60.23,132.21 57.56,129.54 v1(51.02,129.54) 51.02,130.01 49.71,131.32 48.74,131.32 48.36,131.7 39.08,131.7 32.61,125.22 v1(29.69,125.22)
PG10: length 112.4
  TOP w0.127: U21.46 53.89,70.31 v1(53.12,69.53) 52.93,69.34 51.5,69.34 50.74,70.1 35.4,70.1 v1(34.89,70.61) ; v1(50.26,129.54) 50.77,129.03 51.56,129.03 51.67,129.15 U7.125 ; CN6.21 v1(28.42,123.95)
  BOTTOM w0.127: v1(34.89,70.61) 33.88,71.63 33.37,71.63 30.22,74.78 30.22,76.38 29.38,77.22 29.38,90.3 26.05,93.63 26.05,97.96 26.38,98.3 26.38,100.8 27.36,101.77 27.36,110.35 26.26,111.46 26.26,121.79 v1(28.42,123.95) 29.03,124.56 32.45,124.56 39.21,131.32 46.45,131.32 47.47,130.3 49.88,130.3 50.26,129.92 v1(50.26,129.54) ; 53.12,71.16 v1(53.12,69.53)
PG11: length 195.7
  TOP w0.127: v1(106.5,92.38) 103.04,92.38 101.82,93.6 96.79,93.6 95.12,91.92 85.67,91.92 83.41,89.66 83.41,86.26 82.95,85.8 70.81,85.8 69.89,84.89 62.68,84.89 61.84,85.72 51.25,85.72 50.49,84.96 50.49,82.58 49.32,81.41 49.32,80.34 48.53,79.55 44.95,79.55 44.24,80.26 44.24,81.33 38.75,86.82 32.81,86.82 30.58,84.58 21.81,84.58 v1(21.43,84.96) ; v1(28.24,120.09) 28.19,120.14 CN6.27 25.19,120.14 24.56,119.51 24.56,115.47 22.5,113.41 v1(22.5,112.12) ; v1(107.64,110.08) 107.28,110.44 105.94,110.44 R93.2 ; v1(50.51,128.09) 50.57,128.09 51.12,128.65 U7.126
  BOTTOM w0.127: v1(21.43,84.96) 21.18,85.22 21.18,88.13 17.31,92 17.31,102.04 16.22,103.12 16.22,105.09 17.31,106.17 17.31,107.85 20.8,111.34 20.8,111.38 21.53,112.12 v1(22.5,112.12) ; v1(28.24,120.09) 28.92,120.78 31.97,120.78 39.59,128.4 44.8,128.4 45.05,128.65 46.07,128.65 46.63,128.09 v1(50.51,128.09) ; v1(106.5,92.38) 106.5,93.73 107.13,94.36 107.13,95.33 108.35,96.55 108.35,109.37 v1(107.64,110.08)
PG12: length 55.5
  TOP w0.127: CN6.31 v1(28.29,117.6) ; v1(51.33,128.09) 51.38,128.15 U7.127 ; R116.2 27.19,95.76 v1(27.38,95.57)
  BOTTOM w0.127: v1(27.38,95.57) 27.24,95.71 27.24,97.25 27.53,97.54 27.53,100.09 28.51,101.07 28.51,111.03 27.4,112.14 27.4,116.71 v1(28.29,117.6) 29.05,118.36 30.58,118.36 39.8,127.58 50.82,127.58 v1(51.33,128.09)
PG13: length 31.1
  TOP w0.127: U7.128 49.23,127.65 R58.2 47.39,128.07 45.64,128.07 v1(45.56,128.14) ; CN6.29 v1(28.16,118.87)
  BOTTOM w0.127: v1(45.56,128.14) 45.49,128.07 39.77,128.07 31.21,119.51 28.8,119.51 v1(28.16,118.87)
PG14: length 33.4
  TOP w0.127: CN6.33 v1(28.29,116.33) ; R61.2 48.86,126.62 v1(50.26,126.62) 50.79,127.15 U7.129
  BOTTOM w0.127: v1(28.29,116.33) 28.92,116.97 30.45,116.97 39.47,125.98 49.63,125.98 v1(50.26,126.62)
PG15: length 165
  TOP w0.127: v1(50.64,125.35) 50.77,125.48 51.78,125.48 51.95,125.65 U7.132 ; R228.1 87.09,23.62 80.13,23.62 79.59,24.17 79.59,27.65 79.2,28.04 78.35,28.04 v1(78.21,27.9) ; CN6.35 27.65,115.06 28.16,115.57 v1(28.29,115.57)
  BOTTOM w0.127: v1(50.64,125.35) 50.51,125.22 39.97,125.22 30.58,115.82 28.54,115.82 v1(28.29,115.57) 28.04,115.57 27.65,115.19 27.65,112.39 28.76,111.29 28.76,100.87 27.78,99.89 27.78,97.28 27.5,97 27.5,96.13 27.86,95.77 27.86,93.52 30.52,90.86 30.52,77.75 31.72,76.54 31.72,75.43 33.75,73.41 34.77,73.41 43.15,65.02 43.15,46.41 57.04,32.51 70.83,32.51 71.22,32.13 73.04,32.13 77.4,27.78 78.09,27.78 v1(78.21,27.9)
PH0: length 12.9
  TOP w0.203: U7.23 65.75,115.07 66.26,114.55 66.52,114.55 66.95,114.12 66.95,112.57 66.39,112.01 ; X2.2 65.63,109.22 64.99,109.86 65.96,110.82 65.96,111.43
PH1: length 8.3
  TOP w0.203: U7.24 66.25,116.34 68.78,113.82 68.78,112.73 67.79,111.73 ; R95.1 67.41,111.38
PWR_ENN: length 13.8
  TOP w0.127: v1(68.42,48.46) 68.42,48.66 69.06,49.3 U23.28 ; v1(73.25,46.1) 74.39,46.1 R262.1 74.52,44.96 74.9,44.58 76.42,44.58 76.93,45.09 U37.3
  BOTTOM w0.127: v1(68.42,48.46) 68.66,48.46 69.11,48.02 69.11,46.99 70,46.1 v1(73.25,46.1)
PWR_EXT: length 80.3
  TOP w0.127: U23.39 67.12,56.16 R169.1 R170.2 69.01,57.1 70.91,57.1 71.32,57.51 79.57,57.51 81.1,55.98 82.14,55.98 95.32,42.8 95.32,40.87 97.56,38.63 97.56,36.78 98.09,36.25 102.51,36.25 102.9,36.64 102.9,55.82 106.52,59.44 111.47,59.44 JP18.2
RESET#: length 247.6
  TOP w0.127: v1(57.63,99.75) 58.03,100.15 62.07,100.15 63.19,101.27 v1(63.37,101.27) ; v1(59.02,42.57) 58.29,42.57 53.56,37.85 53.56,31.37 52.42,30.23 52.42,17.78 55.34,14.86 55.34,13.08 55.59,12.83 C141.2 57.94,12.77 B1.3 B1.2 ; U23.18 65.12,47.5 64.94,47.68 v1(64.94,47.73) ; v1(92.93,114.05) 92.93,112.12 93.19,111.86 95.5,111.86 96.03,111.33 101.39,111.33 102.08,112.01 102.08,114.55 103.35,115.82 106.65,115.82 R79.1 107.66,116.84 109.57,116.84 111.73,114.68 JP9.1 ; v1(56.36,72.59) 56.39,72.56 U21.41 ; v1(112.59,90.4) 112.59,90.35 114.07,88.87 114.07,85.95 113.38,85.27 112.8,85.27 112.44,85.62 RS1.3 ; v1(67.28,119.38) 66.75,118.85 U7.25 66.75,116.38 69.28,113.84 69.28,110.59 R96.1 68.8,110.11 v1(68.27,110.11)
  BOTTOM w0.127: JP9.1 111.17,112.47 111.17,109.35 111.75,108.76 111.75,100.33 111.25,99.82 111.25,96.24 113.51,93.98 113.51,91.9 112.59,90.98 v1(112.59,90.4) ; v1(59.02,42.57) 58.52,43.08 58.52,44.32 61.56,47.37 64.74,47.37 64.94,47.57 v1(64.94,47.73) 64.94,47.8 64.46,48.29 64.46,58.57 63.14,59.89 63.14,63.96 62.58,64.52 62.58,65.66 60.83,67.41 60.83,72.03 59.51,73.36 57.75,73.36 56.99,72.59 v1(56.36,72.59) 56.03,72.92 56.03,73.53 57.12,74.63 57.12,85.09 55.47,86.74 55.47,91.19 57.25,92.96 57.25,98.93 57.63,99.31 v1(57.63,99.75) ; v1(67.28,119.38) 67.66,119.76 67.66,120.78 67.53,120.9 67.53,121.41 68.17,122.05 74.9,122.05 77.18,119.76 86.96,119.76 88.23,118.49 91.92,118.49 92.93,117.47 v1(92.93,114.05) ; v1(63.37,101.27) 63.37,102.36 61.77,103.96 61.77,107.92 63.7,109.86 67.91,109.86 68.17,110.11 v1(68.27,110.11)
SHUNT_X1000: length 16.1
  TOP w0.127: T2.3 62.52,91.75 v1(62.58,91.69) ; U14.2 72.79,90.65 72.46,90.32 72.46,89.48 71.88,88.9 64.18,88.9 64.03,88.75 v1(64.03,88.65)
  BOTTOM w0.127: v1(62.58,91.69) 62.58,90.09 v1(64.03,88.65)
STL_USB_DM: length 42.4
  TOP w0.155: v1(108.04,50.22) 108.18,50.36 111.03,50.36 111.35,50.04 ; U23.32 70.65,51.3 70.71,51.36 72.35,51.36 v1(72.49,51.22)
  BOTTOM w0.155: v1(108.04,50.22) 107.9,50.36 104.3,50.36 103.6,51.05 96.84,51.05 96.54,51.36 72.63,51.36 v1(72.49,51.22)
STL_USB_DP: length 42.4
  TOP w0.155: v1(108.04,50.88) 108.18,50.74 111.03,50.74 111.35,51.05 ; v1(72.49,51.88) 72.35,51.74 70.71,51.74 70.65,51.8 U23.33
  BOTTOM w0.155: v1(72.49,51.88) 72.63,51.74 96.69,51.74 97,51.44 103.76,51.44 104.46,50.74 107.9,50.74 v1(108.04,50.88)
STM_JTCK_SWCLK: length 8.5
  TOP w0.127: U23.37 70.36,54.9 70.58,55.12 74.77,55.12 CN16.3
STM_JTMS_SWDIO: length 11.8
  TOP w0.127: CN16.1 77.31,55.12 77.31,53.21 76.8,52.7 71.85,52.7 71.72,52.83 70.96,52.83 70.43,52.3 U23.34
STM_RST: length 3.4
  TOP w0.127: R181.1 C91.2 59.03,50.3 U23.7
T_JTDO: length 20.9
  TOP w0.127: U23.31 70.58,50.8 71.08,50.29 73.76,50.29 74.14,49.91 74.14,48.26 72.61,46.73 U24.3 72.61,44.7 v1(72.23,44.32) ; U23.16 64.12,44.68 64.48,44.32 v1(65.6,44.32)
  BOTTOM w0.127: v1(72.23,44.32) v1(65.6,44.32)
T_SWDIO_IN: length 4
  TOP w0.127: U23.25 70.28,47.8 72.11,45.97 U24.2
TS_SHIELD: length 2.6
  TOP w0.127: R37.2 v1(60.67,145.8)
  L2_VCC w0.254: 71.6,138.3 71.72,138.43 ; v1(60.67,145.8) 60.67,147.45
  vias: v1(60.17,158.5) v1(60.17,155.57) v1(60.17,153.16) v1(60.17,150.37) v1(60.17,147.7) v1(60.29,160.66) v1(62.07,160.66) v1(62.07,147.7) v1(63.98,147.7) v1(64.23,160.66) v1(65.88,147.7) v1(66.39,160.66) v1(66.52,142.88) v1(67.28,145.67) v1(67.66,142.88) v1(68.04,147.7) v1(68.55,160.66) v1(70.58,147.7) v1(70.83,160.66) v1(73.12,160.66) v1(73.12,158.37) v1(73.12,155.57) v1(73.12,153.16) v1(73.12,150.37) v1(73.12,147.7) v1(73.12,146.81) v1(74.01,143.13)
U5V: length 117.7
  TOP w0.508: v1(21.43,141.86) 21.43,142.24 28.54,149.35 28.54,156.59 26.77,158.37 R2.1 ; D6.1 12.47,70.41 v1(12.41,70.36) 12.41,70.32 11.18,69.09 9.24,69.09 7.46,67.31 7.46,64.77 JP17.6
  BOTTOM w0.508: v1(12.41,70.36) 13.56,71.5 13.56,76.2 15.84,78.49 15.84,85.09 10.38,90.55 10.38,108.08 16.73,114.43 16.73,119.76 19.27,122.3 19.27,130.05 21.43,132.21 v1(21.43,141.86)
U5V_STLINK: length 104.6
  TOP w0.508: 82.73,45.9 U37.7 ; U37.7 83.8,46.35 ; U37.7 81.66,46.35 ; U37.7 82.73,46.81 ; 84.47,45.47 C143.2 ; C143.2 84.93,45.92 ; C143.2 84.93,45.01 ; U37.6 83.8,45.09 ; U37.6 82.73,44.63 ; U37.6 82.73,45.54 ; U37.6 81.66,45.09
  TOP w0.762: v1(82.14,54.86) 82.14,54.61 84.93,51.82 84.93,46.23 ; v1(68.93,58.29) 68.88,58.24 68.83,58.29 68.07,58.29 67.43,58.93 40.81,58.93 37.97,56.08 29.38,56.08 23.72,50.42 v1(22.32,50.42)
  BOTTOM w0.762: v1(68.93,58.29) 68.98,58.24 80.54,58.24 81.88,56.9 81.88,55.12 v1(82.14,54.86) ; JP17.4 10.51,61.47 14.57,61.47 21.43,54.61 21.43,50.93 21.94,50.42 v1(22.32,50.42)
  vias: v1(22.32,49.66) v1(69.69,58.29) v1(81.38,54.86)
USART1_RTS_3V3: length 171.5
  TOP w0.127: U12.6 21.05,95.25 v1(21.3,95) ; U10.14 111.73,108.62 112.16,109.05 v1(112.16,109.32) ; v1(29.69,66.45) 31.82,68.58 40.1,68.58 43.22,65.46 49.93,65.46 51.15,66.67 54.96,66.67 55.85,67.56 114.07,67.56 114.6,67.03 117.19,67.03 v1(117.54,67.39)
  BOTTOM w0.127: v1(112.16,109.32) 112.16,100.28 111.5,99.62 111.5,96.52 118.74,89.28 118.74,71.75 117.54,70.56 v1(117.54,67.39) ; v1(21.3,95) 21.3,91.95 23.72,89.53 23.72,71.5 28.77,66.45 v1(29.69,66.45)
USB_RENUMN: length 54
  TOP w0.127: v1(110.33,53.85) 111.47,53.85 112.36,54.74 R173.1 ; v1(67.53,52.83) 67.62,52.92 U23.38
  BOTTOM w0.127: v1(110.33,53.85) 110.33,50.29 108.93,48.9 97,48.9 95.47,50.42 72.23,50.42 71.79,50.86 68.1,50.86 67.53,51.44 v1(67.53,52.83)
VLCD: length 4.7
  TOP w0.127: R94.2 C58.2 81.63,108.84 TP7.1
VUSB_ST_LINK: length 158.2
  TOP w0.508: 78.45,49.07 R268.1 ; R268.1 78.45,49.99 ; R268.1 78,49.53 ; C145.1 75.66,47.45 ; C145.1 75.2,46.99 ; C145.1 76.12,46.99 ; R262.2 74.97,46.99 ; R262.2 74.52,47.45 ; R262.2 74.06,46.99 ; 76.41,46.35 U37.2 ; U37.2 78.55,46.35 ; U37.2 77.48,45.9 ; U37.2 77.48,46.81 ; 78,50.8 R110.1 78.45,50.34 ; U37.1 78.55,47.62 ; U37.1 77.48,47.17 ; U37.1 76.41,47.62 ; U37.1 77.48,48.08
  TOP w0.762: CN17.1 114.94,55.85 113.89,56.9 R167.1 112.36,57.66 112.11,57.91 107.28,57.91 104.74,55.37 104.74,44.07 v1(104.62,43.94) ; v1(52.93,40.74) 51.17,40.74 46.83,45.09 31.21,45.09 29.43,46.86 v1(22.83,46.86) ; D8.1 v1(17.04,70.31)
  BOTTOM w0.762: v1(104.62,43.94) 104.24,43.56 89.76,43.56 89,44.32 89,45.85 87.34,47.5 75.79,47.5 v1(75.41,47.88) ; v1(52.93,40.74) 52.95,40.74 54.07,39.62 60.17,39.62 61.94,41.4 61.94,43.94 63.21,45.21 73.88,45.21 74.64,45.97 v1(74.64,47.88) ; v1(17.04,70.31) 18.76,68.58 18.76,62.48 24,57.25 24,48.67 22.83,47.5 v1(22.83,46.86)

## Copper pours and planes (outline as drawn)
+1V8 on TOP: 58.64,39.88 60.42,39.88 61.82,38.48 67.15,38.48 68.04,39.37 71.22,39.37 71.6,38.99 71.6,36.7 71.34,36.45 61.69,36.45 60.29,35.05 58.13,35.05 57.88,35.31 57.88,39.12
+1V8 on BOTTOM: 76.17,37.59 76.17,33.27 77.06,32.38 78.07,32.38 78.96,31.5 79.93,31.5 80.45,30.97 80.98,30.97 81.12,31.11 83.79,31.11 84.17,30.73 84.17,29.21 83.79,28.83 82.21,28.83 82.17,28.86 81.85,28.86 81.3,29.41 81.3,29.67 80.99,29.97 79.81,29.97 79.64,30.14 79.05,30.14 78.6,29.69 76.57,29.69 74.01,32.26 74.01,35.94 73.5,36.45 70.45,36.45 70.07,36.83 70.07,38.99 70.45,39.37 74.39,39.37
+3V3 on TOP (solid shape): 44.93,41.4 44.93,40.26 43.59,40.26 43.59,38.73 44.93,38.73 44.93,38.38 44.14,38.38 44.14,37.57 44.93,37.57 44.93,36.49 44.15,36.49 44.15,35.94 43.28,35.94 43.28,36.07 42.77,36.07 42.77,35.94 42.26,35.94 42.13,36.07 42.13,36.18 43.56,36.18 43.56,37.22 42.49,37.22 42.49,36.18 42.13,36.18 42.13,37.08 41.75,37.47 40.74,37.47 40.35,37.85 40.35,41.4 40.74,41.78 44.55,41.78
+3V3 on TOP: 64.23,38.99 64.1,39.12 64.1,41.02 64.23,41.15 66.14,41.15 66.57,40.72 68.27,40.72 68.52,40.46 68.52,39.88 68.29,39.65 67.81,39.65 67.15,38.99
+3V3 on L2_VCC: 61.8,14.48 41.22,35.05 12.77,35.05 11.65,36.17 11.65,58.82 13.03,60.2 16.84,60.2 17.75,61.11 17.75,68.94 16.84,69.85 8.71,69.85 7.59,70.97 7.59,101.24 12.16,105.81 12.16,151.28 16.58,155.7 23.95,155.7 24.61,156.36 24.61,159.62 23.95,160.27 22.43,160.27 21.81,160.89 21.81,165.25 22.93,166.37 97.65,166.37 98.01,166.01 98.01,161.54 59.81,161.54 59.15,160.89 59.15,157.48 38.43,157.48 38.07,157.84 38.07,160.38 37.67,160.78 33.14,160.78 32.23,159.87 32.23,154.58 33.39,153.42 35.27,153.42 35.27,148.19 34.66,147.57 21.2,147.57 17.75,144.12 17.75,96.16 19.78,94.13 19.78,90.78 18.51,89.51 18.51,76.6 19.68,75.44 29.07,75.44 33.75,70.76 33.75,56.24 32.63,55.12 19.68,55.12 18.51,53.95 18.51,45.11 19.93,43.69 46.85,43.69 58.03,32.51 63.32,32.51 64.74,33.93 64.74,40.64 70.83,40.64 70.83,34.69 72.51,33.02 79.11,33.02 81.65,30.48 89.23,30.48 89.88,31.14 89.88,34.18 91.51,35.81 101.97,35.81 102.58,35.2 102.58,24.49 101.97,23.88 75.56,23.88 66.16,14.48
+3V3_STLINK on L2_VCC: 64.74,41.15 64.74,44.05 61.8,46.99 56.21,46.99 55.85,47.35 55.85,58.06 56.46,58.67 77.04,58.67 82.62,64.26 110.1,64.26 112.24,62.12 112.24,53.19 106.04,46.99 79.47,46.99 79.22,47.24 79.22,50.29 78.58,50.93 70.33,50.93 69.95,50.55 69.95,44.96 70.83,44.07 70.83,41.15
+3V6 on TOP: 39.59,42.55 39.59,39.5 39.21,39.12 34.39,39.12 33.62,38.35 33.62,34.04 33.37,33.78 31.97,33.78 31.72,34.04 31.72,38.61 29.94,40.39 29.94,42.93 30.58,43.56 38.58,43.56
+5V on TOP (solid shape): 44.15,33.87 44.93,33.87 44.93,33.78 44.04,32.89 44.04,30.86 43.91,30.73 41.12,30.73 40.61,31.24 43.91,31.24 43.91,33.02 42.39,33.02 42.39,31.24 40.61,31.24 40.48,31.37 40.48,33.78 41.12,34.42 43.91,34.42 44.04,34.54 44.15,34.54
+5V on TOP (solid shape): 45.17,16.35 45.94,16.35 45.94,16.26 45.05,15.37 45.05,13.34 44.93,13.21 44.93,11.43 44.67,11.18 41.75,11.18 41.5,11.43 41.5,13.59 44.8,13.59 44.8,15.37 43.27,15.37 43.27,13.59 41.5,13.59 41.5,16.26 42.13,16.89 44.93,16.89 45.05,17.02 45.17,17.02
+5V on BOTTOM (solid shape): 114.14,152.88 113.63,152.37 113.13,152.88 113.13,153.8 114.14,153.8
+5V on TOP: 34.51,37.08 35.66,37.08 36.04,36.7 36.04,33.02 35.78,32.77 34.26,32.77 34,33.02 34,36.58
+5V on L2_VCC: 0.51,0.51 0.51,44.14 1.18,50.53 0.51,56.92 0.51,172.21 27.27,172.21 27.27,170.94 27.4,170.81 28.16,170.81 28.29,170.94 28.29,172.21 31.97,172.21 31.97,170.81 32.1,170.69 32.86,170.69 32.99,170.81 32.99,172.21 126.49,172.21 126.49,146.56 112.85,146.56 98.52,160.89 98.52,166.22 97.86,166.88 22.72,166.88 21.3,165.46 21.3,160.68 22.22,159.77 23.74,159.77 24.1,159.41 24.1,156.57 23.74,156.21 16.37,156.21 11.65,151.49 11.65,106.02 7.08,101.45 7.08,70.76 8.5,69.34 16.63,69.34 17.24,68.73 17.24,61.32 16.63,60.71 12.82,60.71 11.14,59.03 11.14,35.96 12.56,34.54 41.01,34.54 61.44,14.12 61.44,0.51
GND on TOP (solid shape): 123.03,138.56 122.11,138.56 121.6,139.06 122.11,139.57 123.03,139.57
GND on TOP (solid shape): 48.74,41.3 48.74,38.35 46.83,36.45 46.83,33.78 47.34,33.27 47.34,30.99 47.21,30.86 44.93,30.86 44.8,30.99 44.8,31.24 46.7,31.24 46.7,33.02 45.18,33.02 45.18,31.24 44.8,31.24 44.8,32.89 45.31,33.4 45.31,36.04 45.31,36.04 45.31,37.57 45.97,37.57 45.97,38.38 45.31,38.38 45.31,38.73 46.77,38.73 46.77,40.26 45.31,40.26 45.31,41.4 45.69,41.78 48.25,41.78
GND on TOP (solid shape): 49.75,23.88 49.75,20.83 47.85,18.92 47.85,16.26 48.36,15.75 48.36,13.46 48.23,13.34 45.94,13.34 45.82,13.46 45.82,13.59 47.59,13.59 47.59,15.37 46.07,15.37 46.07,13.59 45.82,13.59 45.82,15.37 46.32,15.88 46.32,18.51 46.32,18.51 46.32,19.91 47.11,19.91 47.11,20.73 46.32,20.73 46.32,21.21 47.78,21.21 47.78,22.73 46.32,22.73 46.32,23.88 46.7,24.26 49.37,24.26
GND on TOP: 18.48,0.61 0.83,0.61 0.6,0.84 0.6,13.87 0.96,14.22 7.66,14.22 8.53,13.36 8.53,11 8.91,10.62 15.36,10.62 16.63,9.35 16.61,9.32 16.61,4.78 16.83,4.55 18.51,4.55 18.69,4.37 18.69,2.97 18.97,2.69 34.94,2.69 38.17,5.92 60.09,5.92 62.5,3.51 74.64,3.51 75.61,4.47 75.61,12.9 74.95,13.56 72.84,13.56 72.49,13.92 72.49,27.74 72.79,28.04 73.78,28.04 73.93,27.89 73.93,26.26 74.19,26.01 74.19,25.07 74.39,24.87 74.87,24.87 75.29,25.29 77.76,25.29 77.79,25.32 77.79,25.55 77.92,25.68 79.19,25.68 79.37,25.5 79.37,22.83 78.99,22.45 76.9,22.45 76.7,22.25 76.7,17.55 77.29,16.97 77.29,16.31 77.57,16.03 78.73,16.03 78.99,15.77 78.99,6.63 83.23,2.39 88.49,2.39 91.05,4.95 91.05,10.95 92.42,12.32 97.96,12.32 99.1,13.46 99.1,14.83 99.21,14.94 99.87,14.94 101.14,16.21 125.39,16.21 126.41,15.19 126.41,0.89 126.14,0.62 18.5,0.62
GND on TOP: 56.9,109.26 59.22,109.26 59.41,109.07 59.41,104.77 58.91,104.27 54.21,104.27 53.7,104.78 53.7,109.46 53.78,109.53 56.62,109.53
GND on TOP: outline of 145 points within 0.53,27.52 35.96,172.09 ; 3 cut-outs
GND on TOP: 36.67,38.61 39.14,38.61 39.39,38.35 39.39,35.71 38.98,35.31 36.8,35.31 36.42,35.69 36.42,38.35
GND on TOP: 72.05,102.96 63.99,102.96 62.58,104.37 62.58,107.23 63.05,107.7 72.79,107.7 73.86,106.63 73.86,104.78
GND on TOP: 97.73,32.64 116.91,32.64 118.36,34.09 118.36,39.67 115.16,42.88 107.54,42.88 107.52,42.86 107.14,42.86 105.84,44.17 105.84,51.08 106.5,51.74 109.52,51.74 109.85,51.41 109.85,50.16 110.56,49.45 117.06,49.45 117.88,50.27 117.88,51.94 117.44,52.37 116.71,52.37 116.05,53.04 116.05,59.26 122.12,65.33 122.12,86.33 121.33,87.12 118.87,87.12 117.93,88.06 117.93,89.92 114.83,93.01 114.83,103.61 115.67,104.44 119.75,104.44 121.76,106.45 121.76,114.27 120.43,115.61 113.21,115.61 112.03,116.79 112.03,118.49 112.34,118.8 113.56,118.8 114.04,119.28 114.04,131.72 115.11,132.79 123.36,132.79 124.56,133.99 124.56,141.27 122.4,143.43 122.4,153.95 122.75,154.31 126.1,154.31 126.43,153.97 126.43,15.16 114.7,15.16 114.09,15.77 114.09,15.8 115.51,17.22 115.51,27.46 115.03,27.94 112.52,27.94 112.34,27.76 112.34,26.87 111.93,26.47 97.83,26.47 97.35,26.95 97.35,32.26
GND on TOP: 56.58,57.81 57.25,57.15 57.25,46.23 56.48,45.47 56.48,43.81 55.21,42.55 52.42,42.55 50.39,44.58 50.39,57.15 51.05,57.81
GND on TOP: 21.56,43.08 26.89,43.08 27.22,42.75 27.22,36.63 26.87,36.27 21.41,36.27 21.02,36.65 21.02,42.55
GND on TOP: 64.23,33.78 63.98,34.04 63.98,35.81 64.23,36.07 71.09,36.07 71.22,35.94 71.22,34.04 70.96,33.78
GND on BOTTOM: 50.26,57.15 60.67,57.15 60.93,56.9 60.93,48.51 56.36,43.94 51.28,43.94 49.75,45.47 49.75,56.64
GND on BOTTOM: 63.72,107.7 72.36,107.7 73.63,106.43 73.63,103.63 72.87,102.87 64.48,102.87 62.71,104.65 62.71,106.68
GND on BOTTOM: outline of 122 points within 0.55,0.58 126.43,172.14
GND on BOTTOM: 30.7,65.53 35.27,65.53 38.32,62.48 38.32,55.37 40.86,52.83 40.86,46.74 52.04,35.56 52.04,35.53 53.65,33.91 53.65,26.73 52.42,25.5 52.42,19.97 52.48,19.92 52.48,19.14 47.19,13.85 43.6,13.85 42.71,14.74 42.71,20.08 46.24,23.61 46.24,23.62 46.7,24.08 46.7,27.05 47.34,27.69 47.34,28.07 47.05,28.36 45.73,28.36 44.88,29.21 27.15,29.21 26.64,29.72 26.64,31.5 28.42,33.27 28.42,63.25
GND on BOTTOM: 54.32,108.97 58.39,108.97 58.9,108.46 58.9,103.12 57.63,101.85 54.07,101.85 53.94,101.98 53.94,108.58
GND on L3_GND: 0.51,0.51 0.51,44.14 1.18,50.53 0.51,56.92 0.51,172.21 27.27,172.21 27.27,170.94 27.4,170.81 28.16,170.81 28.29,170.94 28.29,172.21 31.97,172.21 31.97,170.81 32.1,170.69 32.86,170.69 32.99,170.81 32.99,172.21 126.49,172.21 126.49,0.51
VDD on L2_VCC: outline of 84 points within 18.26,0.51 126.49,161.04
VDD_ADJ on TOP (solid shape): 45.94,23.88 45.94,22.73 44.61,22.73 44.61,21.21 45.94,21.21 45.94,20.73 45.28,20.73 45.28,19.91 45.94,19.91 45.94,18.96 45.17,18.96 45.17,18.41 44.16,18.41 44.16,18.54 43.66,18.54 43.66,18.41 43.28,18.41 43.15,18.54 43.15,18.66 44.44,18.66 44.44,19.7 43.38,19.7 43.38,18.66 43.15,18.66 43.15,19.56 42.77,19.94 41.75,19.94 41.37,20.32 41.37,23.88 41.75,24.26 45.56,24.26
VDD_MCU on L2_VCC: 77.8,103.12 76.68,104.25 76.68,108.06 73.48,111.25 46.56,111.25 44.93,112.88 44.93,150.73 41.73,153.92 33.6,153.92 32.73,154.79 32.73,159.66 33.35,160.27 37.46,160.27 37.56,160.17 37.56,157.63 38.22,156.97 59.15,156.97 59.15,147.47 59.16,147.46 59.16,147.06 60.04,146.18 60.04,145.54 60.55,145.03 63.98,145.03 64.1,144.91 64.1,142.37 65.25,141.22 67.68,141.22 71.24,137.67 72.84,137.67 74.5,139.32 83.81,139.32 86.58,136.55 86.58,115.46 91.05,111 100.96,111 101.57,110.38 101.57,103.99 100.7,103.12
VDDA on TOP: 87.6,105.03 87.22,105.41 87.22,106.93 86.96,107.19 86.96,112.27 87.09,112.39 89.63,112.39 92.3,109.73 92.3,105.28 92.04,105.03
(no net) on TOP: 41.5,16.26 42.13,16.89 44.93,16.89 45.05,17.02 45.82,17.02 45.94,16.89 45.94,16.26 45.05,15.37 45.05,13.34 44.93,13.21 44.93,11.43 44.67,11.18 41.75,11.18 41.5,11.43
(no net) on TOP: 43.91,30.73 41.12,30.73 40.48,31.37 40.48,33.78 41.12,34.42 43.91,34.42 44.04,34.54 44.8,34.54 44.93,34.42 44.93,33.78 44.04,32.89 44.04,30.86
(no net) on TOP: 43.28,18.41 43.15,18.54 43.15,19.56 42.77,19.94 41.75,19.94 41.37,20.32 41.37,23.88 41.75,24.26 45.56,24.26 45.94,23.88 45.94,18.67 45.69,18.41
(no net) on TOP: 42.26,35.94 42.13,36.07 42.13,37.08 41.75,37.47 40.74,37.47 40.35,37.85 40.35,41.4 40.74,41.78 44.55,41.78 44.93,41.4 44.93,36.2 44.67,35.94
(no net) on TOP: 49.37,24.26 49.75,23.88 49.75,20.83 47.85,18.92 47.85,16.26 48.36,15.75 48.36,13.46 48.23,13.34 45.94,13.34 45.82,13.46 45.82,15.37 46.32,15.88 46.32,23.88 46.7,24.26
(no net) on TOP: 48.36,41.78 48.74,41.4 48.74,38.35 46.83,36.45 46.83,33.78 47.34,33.27 47.34,30.99 47.21,30.86 44.93,30.86 44.8,30.99 44.8,32.89 45.31,33.4 45.31,41.4 45.69,41.78
A0_1DELAY on BOTTOM (solid shape): 52.93,63.72 53.44,64.23 53.44,62.87 52.42,62.87 52.42,64.23
A0_2DELAY on BOTTOM (solid shape): 54.33,63.72 54.83,64.23 54.83,62.87 53.82,62.87 53.82,64.23
A1 on BOTTOM (solid shape): 59.4,64.04 58.89,64.55 58.39,64.04 58.39,65.41 59.4,65.41
A1_1DELAY on BOTTOM (solid shape): 60.8,64.04 60.29,64.55 59.79,64.04 59.79,65.41 60.8,65.41
A1_BUF on BOTTOM (solid shape): 59.4,63.79 59.4,62.87 58.39,62.87 58.39,63.79 58.9,64.29
A1_BUF on BOTTOM (solid shape): 60.8,63.79 60.8,62.87 59.79,62.87 59.79,63.79 60.29,64.29
A20 on TOP (solid shape): 54.2,111.12 53.18,111.12 53.18,112.49 53.69,111.98 54.2,112.49
A21 on TOP (solid shape): 55.72,111.12 54.71,111.12 54.71,112.49 55.21,111.98 55.72,112.49
A22 on TOP (solid shape): 57.25,111.12 56.23,111.12 56.23,112.49 56.74,111.98 57.25,112.49
E5V on TOP: 12.29,41.45 14.9,41.45 16.61,43.15 19.3,43.15 19.83,42.62 19.83,36.6 19.45,36.22 6.42,36.22 5.15,34.95 3.85,34.95 2.61,36.2 2.61,38.86 3.63,39.88 3.65,39.88 4.16,40.39 11.22,40.39
LCD_CSN on BOTTOM (solid shape): 56.48,64.48 55.98,63.98 55.47,64.48 55.47,65.41 56.48,65.41
LCD_CSN on BOTTOM (solid shape): 57.88,64.48 57.37,63.98 56.86,64.48 56.86,65.41 57.88,65.41
LCD_NE3_BUF on BOTTOM (solid shape): 55.59,70.61 54.67,70.61 54.17,71.12 54.67,71.63 55.59,71.63
LCD_NE3_BUF on BOTTOM (solid shape): 58.04,71.12 57.53,70.61 56.61,70.61 56.61,71.63 57.53,71.63
LCD_RS on BOTTOM (solid shape): 53.44,64.48 52.93,63.98 52.42,64.48 52.42,65.41 53.44,65.41
LCD_RS on BOTTOM (solid shape): 54.83,64.48 54.32,63.98 53.82,64.48 53.82,65.41 54.83,65.41
LCDSEG0 on TOP (solid shape): 82.9,113.79 81.54,113.79 82.04,114.3 81.53,114.81 82.9,114.81
LCDSEG1 on TOP (solid shape): 82.9,115.19 81.54,115.19 82.04,115.69 81.53,116.2 82.9,116.2
LCDSEG2 on TOP (solid shape): 82.9,116.59 81.98,116.59 81.47,117.09 81.98,117.6 82.9,117.6
LCDSEG3 on TOP (solid shape): 80.74,121.67 79.38,121.67 79.88,122.17 79.38,122.68 80.74,122.68
LCDSEG4 on TOP (solid shape): 80.74,123.19 79.38,123.19 79.88,123.7 79.38,124.21 80.74,124.21
LCDSEG5 on TOP (solid shape): 80.74,126.62 79.38,126.62 79.88,127.12 79.38,127.64 80.74,127.64
LCDSEG6 on TOP (solid shape): 80.74,128.4 79.38,128.4 79.88,128.9 79.38,129.41 80.74,129.41
LCDSEG10 on TOP (solid shape): 80.74,135.13 79.38,135.13 79.88,135.63 79.38,136.14 80.74,136.14
LCDSEG11 on TOP (solid shape): 80.74,136.65 79.38,136.65 79.88,137.16 79.38,137.67 80.74,137.67
LCDSEG12 on TOP (solid shape): 73.37,145.26 72.87,144.75 72.36,145.26 72.36,146.18 73.37,146.18
LCDSEG13 on TOP (solid shape): 70.83,144.82 70.33,145.32 69.82,144.81 69.82,146.18 70.83,146.18
LCDSEG18 on TOP (solid shape): 71.34,108.46 70.33,108.46 70.33,109.82 70.83,109.31 71.34,109.82
LCDSEG19 on TOP (solid shape): 72.74,108.46 71.72,108.46 71.72,109.82 72.23,109.31 72.74,109.82
LCDSEG20 on TOP (solid shape): 74.26,108.46 73.25,108.46 73.25,109.82 73.75,109.31 74.26,109.82
LCDSEG22 on TOP (solid shape): 84.17,124.84 82.81,124.84 83.31,125.35 82.8,125.86 84.17,125.86
LCDSEG23 on TOP (solid shape): 80.74,124.97 79.38,124.97 79.88,125.47 79.38,125.98 80.74,125.98
LCDSEG24 on TOP (solid shape): 59.91,144.56 59.41,145.07 58.9,144.56 58.9,145.92 59.91,145.92
LCDSEG25 on TOP (solid shape): 58.52,144.56 58.01,145.07 57.5,144.56 57.5,145.92 58.52,145.92
LCDSEG26 on BOTTOM (solid shape): 58.52,144.3 58.52,143.38 57.5,143.38 57.5,144.3 58.01,144.81
LCDSEG27 on BOTTOM (solid shape): 56.99,144.3 56.99,143.38 55.98,143.38 55.98,144.3 56.48,144.81
LCDSEG38 on TOP (solid shape): 51.66,109.12 51.66,108.2 50.64,108.2 50.64,109.12 51.15,109.63
LCDSEG39 on TOP (solid shape): 53.18,109.12 53.18,108.2 52.17,108.2 52.17,109.12 52.67,109.63
NE3_1DELAY on BOTTOM (solid shape): 55.98,63.72 56.48,64.23 56.48,62.87 55.47,62.87 55.47,64.23
NE3_1DELAY on BOTTOM (solid shape): 59.15,70.61 57.78,70.61 58.29,71.12 57.79,71.63 59.15,71.63
NE3_2DELAY on BOTTOM (solid shape): 57.37,63.72 57.88,64.23 57.88,62.87 56.86,62.87 56.86,64.23
NETC1_2 on BOTTOM (solid shape): 75.28,115.7 73.91,115.7 74.42,116.21 73.92,116.71 75.28,116.71
NETC2_2 on BOTTOM (solid shape): 75.28,117.35 73.91,117.35 74.42,117.86 73.92,118.36 75.28,118.36
NETC3_1 on TOP (solid shape): 87.47,125.22 86.11,125.22 86.62,125.73 86.11,126.24 87.47,126.24
NETC4_2 on TOP (solid shape): 44.7,160.53 44.2,160.02 43.28,160.02 43.28,161.04 44.2,161.04
NETC4_2 on BOTTOM (solid shape): 81.21,115.82 81.72,115.32 80.36,115.32 80.36,116.33 81.72,116.33
NETC5_2 on TOP (solid shape): 72.45,142.12 72.96,141.6 71.6,141.6 71.6,142.62 72.96,142.62
NETC6_2 on TOP (solid shape): 87.47,121.41 86.11,121.41 86.62,121.92 86.11,122.43 87.47,122.43
NETC7_2 on BOTTOM (solid shape): 56.99,144.56 56.48,145.07 55.98,144.56 55.98,145.92 56.99,145.92
NETC8_1 on TOP (solid shape): 45.82,160.02 44.45,160.02 44.96,160.53 44.45,161.04 45.82,161.04
NETC9_2 on BOTTOM (solid shape): 63.85,112.17 63.85,111.25 62.83,111.25 62.83,112.17 63.34,112.68
NETC10_2 on BOTTOM (solid shape): 78.58,111.76 77.22,111.76 77.73,112.27 77.22,112.78 78.58,112.78
NETC11_1 on TOP (solid shape): 84.17,126.62 82.81,126.62 83.31,127.12 82.8,127.64 84.17,127.64
NETC13_2 on BOTTOM (solid shape): 78.58,113.41 77.22,113.41 77.73,113.92 77.22,114.43 78.58,114.43
NETC14_2 on BOTTOM (solid shape): 78.58,115.06 77.22,115.06 77.73,115.57 77.22,116.08 78.58,116.08
NETC15_1 on TOP (solid shape): 52.83,100.71 52.32,100.2 51.4,100.2 51.4,101.22 52.32,101.22
NETC16_2 on TOP (solid shape): 63.72,109.12 63.72,108.2 62.71,108.2 62.71,109.12 63.21,109.63
NETC17_1 on TOP (solid shape): 83.53,117.98 82.17,117.98 82.68,118.49 82.17,119 83.53,119
NETC34_2 on TOP (solid shape): 57.08,142.12 57.59,141.6 56.23,141.6 56.23,142.62 57.59,142.62
NETC37_2 on TOP (solid shape): 69.28,142.12 69.79,141.6 68.42,141.6 68.42,142.62 69.78,142.62
NETC114_1 on TOP: 27.65,33.02 27.65,36.83 27.91,37.08 30.96,37.08 31.34,36.7 31.34,32.89 31.08,32.64 28.04,32.64
NETC124_1 on TOP: 24.35,34.92 23.97,35.31 20.29,35.31 19.91,34.92 19.91,31.24 18.76,30.1 18.76,27.94 17.75,26.92 17.75,24.64 18,24.38 23.72,24.38 24.35,25.02
NETC124_2 on TOP: 2.06,14.67 1.24,15.49 1.24,24.94 10.08,33.78 18.76,33.78 19.02,33.53 19.02,31.5 18.26,30.73 18.26,28.07 17.37,27.18 17.37,24.64 16.99,24.26 15.46,24.26 14.83,24.89 8.6,24.89 7.97,24.26 7.97,19.43 10.51,16.89 10.51,15.11 10.06,14.67
NETCN2_3 on BOTTOM (solid shape): 59.91,144.56 59.4,145.07 58.9,144.56 58.9,145.92 59.91,145.92
NETCN2_5 on TOP (solid shape): 84.17,123.19 82.81,123.19 83.31,123.7 82.8,124.21 84.17,124.21
NETCN2_7 on BOTTOM (solid shape): 58.23,142.36 58.73,141.86 57.37,141.86 57.37,142.88 58.74,142.88
NETCN2_9 on TOP (solid shape): 87.73,127.51 86.36,127.51 86.87,128.01 86.36,128.52 87.73,128.52
NETCN2_11 on BOTTOM (solid shape): 58.52,144.56 58.01,145.07 57.5,144.56 57.5,145.92 58.52,145.92
NETCN2_13 on TOP (solid shape): 84.17,128.52 82.81,128.52 83.31,129.03 82.8,129.54 84.17,129.54
NETCN2_21 on TOP (solid shape): 64.39,142.11 63.88,141.6 62.96,141.6 62.96,142.62 63.88,142.62
NETCN2_23 on TOP (solid shape): 84.17,130.56 82.81,130.56 83.31,131.06 82.8,131.57 84.17,131.57
NETCN3_8 on BOTTOM (solid shape): 113.64,152.11 114.14,152.62 114.14,151.26 113.13,151.26 113.13,152.62
NETCN7_24 on BOTTOM (solid shape): 59.02,117.06 58.52,116.55 58.01,117.06 58.01,117.98 59.02,117.98
NETCN7_25 on BOTTOM (solid shape): 59.15,112.74 58.64,112.24 58.13,112.74 58.13,113.67 59.15,113.67
NETCN7_33 on TOP (solid shape): 68.29,112.87 67.79,112.36 67.28,112.87 67.28,113.79 68.29,113.79
NETCN7_34 on TOP (solid shape): 66.64,112.87 66.14,112.36 65.63,112.87 65.63,113.79 66.64,113.79
NETCN11_18 on TOP (solid shape): 53.94,100.2 52.58,100.2 53.09,100.71 52.58,101.22 53.94,101.22
NETCN11_20 on TOP (solid shape): 56.99,100.2 55.63,100.2 56.14,100.71 55.63,101.22 56.99,101.22
NETCN12_12 on TOP (solid shape): 50.26,109.12 50.26,108.2 49.24,108.2 49.24,109.12 49.75,109.63
NETCN12_18 on BOTTOM (solid shape): 57.63,112.05 57.63,111.12 56.61,111.12 56.61,112.05 57.12,112.55
NETCN12_20 on BOTTOM (solid shape): 55.72,112.05 55.72,111.12 54.71,111.12 54.71,112.05 55.21,112.55
NETCN22_1 on TOP: 9.11,24.38 14.45,24.38 15.08,23.75 19.4,23.75 19.65,23.5 19.65,19.94 18.26,18.54 10,18.54 8.73,19.81 8.73,24
NETLD6_2 on TOP (solid shape): 55.88,100.71 55.37,100.2 54.45,100.2 54.45,101.22 55.37,101.22
NETR32_2 on TOP (solid shape): 47.5,131.7 46.99,131.19 46.07,131.19 46.07,132.21 46.99,132.21
NETR33_2 on TOP (solid shape): 58.52,144.3 58.52,143.38 57.5,143.38 57.5,144.3 58.01,144.81
NETR33_2 on TOP (solid shape): 58.77,141.6 57.85,141.6 57.34,142.11 57.85,142.62 58.77,142.62
NETR33_2 on BOTTOM (solid shape): 59.91,141.86 58.99,141.86 58.48,142.37 58.99,142.88 59.91,142.88
NETR35_1 on TOP (solid shape): 64.87,144.56 64.36,145.07 63.85,144.56 63.85,145.92 64.87,145.92
NETR36_2 on TOP (solid shape): 59.91,144.3 59.91,143.38 58.9,143.38 58.9,144.3 59.4,144.81
NETR36_2 on TOP (solid shape): 60.71,142.11 60.2,141.6 59.28,141.6 59.28,142.62 60.2,142.62
NETR36_2 on BOTTOM (solid shape): 59.91,144.3 59.91,143.38 58.9,143.38 58.9,144.3 59.4,144.81
NETR37_1 on TOP (solid shape): 61.82,141.6 60.46,141.6 60.96,142.11 60.45,142.62 61.82,142.62
NETR38_2 on TOP (solid shape): 70.83,144.56 70.83,143.64 69.82,143.64 69.82,144.56 70.33,145.07
NETR38_2 on TOP (solid shape): 70.96,141.6 70.04,141.6 69.53,142.11 70.04,142.62 70.96,142.62
NETR39_1 on TOP (solid shape): 74.14,141.6 73.22,141.6 72.71,142.11 73.22,142.62 74.14,142.62
NETR39_1 on TOP (solid shape): 73.37,143.64 72.36,143.64 72.36,145 72.86,144.49 73.37,145
NETR42_2 on TOP (solid shape): 121.35,139.07 121.86,138.56 120.49,138.56 120.49,139.57 121.85,139.57
NETR48_2 on TOP (solid shape): 79.63,137.16 79.12,136.65 78.2,136.65 78.2,137.67 79.12,137.67
NETR48_2 on TOP (solid shape): 83.31,137.16 82.8,136.65 81.88,136.65 81.88,137.67 82.8,137.67
NETR50_2 on TOP (solid shape): 79.63,135.64 79.12,135.13 78.2,135.13 78.2,136.14 79.12,136.14
NETR50_2 on TOP (solid shape): 83.31,135.64 82.8,135.13 81.88,135.13 81.88,136.14 82.8,136.14
NETR53_2 on TOP (solid shape): 47.5,130.18 46.99,129.67 46.07,129.67 46.07,130.68 46.99,130.68
NETR54_2 on TOP (solid shape): 80.74,129.92 79.82,129.92 79.31,130.43 79.82,130.94 80.74,130.94
NETR56_2 on TOP (solid shape): 79.63,128.91 79.12,128.4 78.2,128.4 78.2,129.41 79.12,129.41
NETR56_2 on TOP (solid shape): 83.06,129.03 82.55,128.52 81.63,128.52 81.63,129.54 82.55,129.54
NETR56_2 on TOP (solid shape): 86.61,131.06 86.11,130.56 85.19,130.56 85.19,131.57 86.11,131.57
NETR62_2 on TOP (solid shape): 79.63,127.13 79.12,126.62 78.2,126.62 78.2,127.64 79.12,127.64
NETR62_2 on TOP (solid shape): 86.61,129.41 86.11,128.91 85.19,128.91 85.19,129.92 86.11,129.92
NETR62_2 on TOP (solid shape): 86.61,128.02 86.11,127.51 85.19,127.51 85.19,128.52 86.11,128.52
NETR64_2 on TOP (solid shape): 79.63,125.48 79.12,124.97 78.2,124.97 78.2,125.98 79.12,125.98
NETR64_2 on TOP (solid shape): 83.06,127.13 82.55,126.62 81.63,126.62 81.63,127.64 82.55,127.64
NETR65_2 on TOP (solid shape): 83.06,125.35 82.55,124.84 81.63,124.84 81.63,125.86 82.55,125.86
NETR65_2 on TOP (solid shape): 86.36,125.73 85.85,125.22 84.93,125.22 84.93,126.24 85.85,126.24
NETR66_2 on TOP (solid shape): 79.63,123.7 79.12,123.19 78.2,123.19 78.2,124.21 79.12,124.21
NETR66_2 on TOP (solid shape): 83.06,123.7 82.55,123.19 81.63,123.19 81.63,124.21 82.55,124.21
NETR66_2 on TOP (solid shape): 86.36,124.08 85.85,123.57 84.93,123.57 84.93,124.59 85.85,124.59
NETR68_2 on TOP (solid shape): 79.63,122.17 79.12,121.67 78.2,121.67 78.2,122.68 79.12,122.68
NETR68_2 on TOP (solid shape): 83.06,121.92 82.55,121.41 81.63,121.41 81.63,122.43 82.55,122.43
NETR68_2 on TOP (solid shape): 86.36,121.92 85.85,121.41 84.93,121.41 84.93,122.43 85.85,122.43
NETR71_2 on TOP (solid shape): 84.42,136.65 83.06,136.65 83.57,137.16 83.06,137.67 84.42,137.67
NETR78_1 on TOP (solid shape): 82.42,118.49 81.92,117.98 80.99,117.98 80.99,119 81.92,119
NETR78_1 on TOP (solid shape): 81.21,117.1 81.72,116.59 80.36,116.59 80.36,117.6 81.72,117.6
NETR81_2 on TOP (solid shape): 81.79,115.7 81.28,115.19 80.36,115.19 80.36,116.2 81.28,116.2
NETR81_2 on BOTTOM (solid shape): 74.17,117.86 73.66,117.35 72.74,117.35 72.74,118.36 73.66,118.36
NETR82_2 on TOP (solid shape): 81.79,114.3 81.28,113.79 80.36,113.79 80.36,114.81 81.28,114.81
NETR82_2 on BOTTOM (solid shape): 74.17,116.2 73.66,115.7 72.74,115.7 72.74,116.71 73.66,116.71
NETR90_1 on TOP (solid shape): 63.85,111.25 62.83,111.25 62.83,112.61 63.34,112.11 63.85,112.62
NETR91_1 on TOP (solid shape): 65.25,111.25 64.23,111.25 64.23,112.61 64.74,112.11 65.25,112.62
NETR97_2 on TOP (solid shape): 71.34,110.08 70.83,109.57 70.33,110.08 70.33,111 71.34,111
NETR97_2 on BOTTOM (solid shape): 77.47,115.57 76.96,115.06 76.04,115.06 76.04,116.08 76.96,116.08
NETR98_2 on TOP (solid shape): 72.74,110.08 72.23,109.57 71.72,110.08 71.72,111 72.74,111
NETR98_2 on BOTTOM (solid shape): 77.47,113.92 76.96,113.41 76.04,113.41 76.04,114.43 76.96,114.43
NETR99_2 on TOP (solid shape): 74.26,110.08 73.76,109.57 73.25,110.08 73.25,111 74.26,111
NETR99_2 on BOTTOM (solid shape): 77.47,112.27 76.96,111.76 76.04,111.76 76.04,112.78 76.96,112.78
NETR103_1 on TOP (solid shape): 50.26,109.38 49.75,109.89 49.24,109.38 49.24,110.74 50.26,110.74
NETR103_1 on TOP (solid shape): 51.66,109.38 51.15,109.89 50.64,109.38 50.64,110.74 51.66,110.74
NETR104_1 on TOP (solid shape): 53.18,109.38 52.68,109.89 52.17,109.38 52.17,110.74 53.18,110.74
NETR156_2 on BOTTOM (solid shape): 54.2,112.05 54.2,111.12 53.18,111.12 53.18,112.05 53.69,112.55
NETSB9_1 on TOP (solid shape): 84.42,135.13 83.06,135.13 83.57,135.63 83.06,136.14 84.42,136.14
NETSB12_1 on TOP (solid shape): 87.73,130.56 86.36,130.56 86.87,131.06 86.36,131.57 87.73,131.57
NETSB14_1 on TOP (solid shape): 87.73,128.91 86.36,128.91 86.87,129.41 86.36,129.92 87.73,129.92
NETSB18_1 on TOP (solid shape): 87.47,123.57 86.11,123.57 86.62,124.08 86.11,124.59 87.47,124.59
NETSB21_1 on TOP (solid shape): 84.17,121.41 82.81,121.41 83.31,121.92 82.8,122.43 84.17,122.43
OPAMP1_INP on TOP (solid shape): 82.77,111.89 81.85,111.89 81.34,112.39 81.85,112.9 82.77,112.9
PA0 on TOP (solid shape): 81.09,112.4 81.6,111.89 80.23,111.89 80.23,112.9 81.59,112.9
PA0 on BOTTOM (solid shape): 82.9,115.32 81.98,115.32 81.47,115.82 81.98,116.33 82.9,116.33
PB2 on TOP (solid shape): 83.06,131.06 82.55,130.56 81.63,130.56 81.63,131.57 82.55,131.57
PB2 on TOP (solid shape): 79.06,130.43 79.57,129.92 78.2,129.92 78.2,130.94 79.56,130.94
PC14 on BOTTOM (solid shape): 58.64,111.98 59.15,112.49 59.15,111.12 58.13,111.12 58.13,112.49
PC15 on BOTTOM (solid shape): 58.52,116.3 59.02,116.8 59.02,115.44 58.01,115.44 58.01,116.81
PD6 on TOP (solid shape): 48.61,131.19 47.25,131.19 47.75,131.7 47.24,132.21 48.61,132.21
PD6 on TOP (solid shape): 48.61,129.67 47.25,129.67 47.75,130.17 47.24,130.68 48.61,130.68
PE4 on TOP (solid shape): 54.2,112.74 53.69,112.24 53.18,112.74 53.18,113.67 54.2,113.67
PE4 on BOTTOM (solid shape): 54.2,112.3 53.69,112.81 53.18,112.3 53.18,113.67 54.2,113.67
PE5 on TOP (solid shape): 55.72,112.74 55.21,112.24 54.71,112.74 54.71,113.67 55.72,113.67
PE5 on BOTTOM (solid shape): 57.63,112.3 57.12,112.81 56.61,112.3 56.61,113.67 57.63,113.67
PE6 on TOP (solid shape): 57.25,112.74 56.74,112.24 56.23,112.74 56.23,113.67 57.25,113.67
PE6 on BOTTOM (solid shape): 55.72,112.3 55.21,112.81 54.71,112.3 54.71,113.67 55.72,113.67
PF9 on TOP (solid shape): 63.85,112.87 63.34,112.36 62.83,112.87 62.83,113.79 63.85,113.79
PF9 on TOP (solid shape): 63.72,109.38 63.22,109.89 62.71,109.38 62.71,110.74 63.72,110.74
PF10 on TOP (solid shape): 65.25,112.87 64.74,112.36 64.23,112.87 64.23,113.79 65.25,113.79
PF10 on BOTTOM (solid shape): 63.85,112.43 63.34,112.94 62.83,112.43 62.83,113.79 63.85,113.79
PG6 on TOP (solid shape): 64.87,144.3 64.87,143.38 63.85,143.38 63.85,144.3 64.36,144.81
PG6 on TOP (solid shape): 65.5,141.6 64.14,141.6 64.64,142.11 64.14,142.62 65.5,142.62
PG10 on BOTTOM (solid shape): 53.91,71.12 54.42,70.61 53.05,70.61 53.05,71.63 54.42,71.63
PH0 on TOP (solid shape): 66.64,111.25 65.63,111.25 65.63,112.61 66.13,112.11 66.64,112.62
PH1 on TOP (solid shape): 68.29,111.25 67.28,111.25 67.28,112.61 67.78,112.11 68.29,112.62
TS_SHIELD on TOP: 73.82,161.1 74.14,160.78 74.39,146.5 74.39,143 73.88,142.49 73.76,142.49 73.5,142.75 73.5,145.16 73.37,145.29 69.82,145.29 69.82,143.76 68.42,142.37 65.63,142.37 64.99,143 64.99,145.29 64.97,145.29 64.97,146.18 63.82,147.32 59.68,147.32 59.64,147.36 59.64,160.67 60.06,161.1
TS_SHIELD on L2_VCC: 71.45,138.18 71.09,138.54 71.09,139.55 68.4,142.24 65.86,142.24 64.99,143.11 64.99,146.16 63.83,147.32 60.02,147.32 59.66,147.68 59.66,160.68 60.02,161.04 74.14,161.04 74.14,139.68 72.63,138.18
U5V_STLINK on TOP: 85.19,44.58 85.06,44.45 81.5,44.45 81.38,44.58 81.38,46.86 81.5,46.99 83.92,46.99 84.04,46.86 84.04,46.1 84.17,45.97 84.3,45.97 84.42,46.1 84.42,46.86 84.55,46.99 85.06,46.99 85.19,46.86
U5V_STLINK on TOP, BOTTOM: 81.12,54.48 81.12,55.24 81.25,55.37 82.26,55.37 82.52,55.12 82.52,54.61 82.26,54.36 81.25,54.36
U5V_STLINK on TOP, BOTTOM: 21.94,50.8 22.7,50.8 22.83,50.67 22.83,49.66 22.57,49.4 22.07,49.4 21.81,49.66 21.81,50.67
U5V_STLINK on TOP, BOTTOM: 69.95,58.67 69.95,57.91 69.82,57.78 68.8,57.78 68.55,58.04 68.55,58.55 68.8,58.8 69.82,58.8
VUSB_ST_LINK on TOP: 76.42,48.26 78.45,48.26 78.71,48.01 78.71,45.85 78.58,45.72 76.42,45.72 76.3,45.85 76.3,46.35 76.17,46.48 74.14,46.48 73.88,46.74 73.88,47.62 74.52,48.26 74.52,50.93 74.9,51.31 78.58,51.31 78.71,51.18 78.71,49.15 78.33,48.77 76.17,48.77 75.91,48.51 75.91,47.75 76.04,47.62 76.17,47.62 76.3,47.75 76.3,48.13

Small or netless copper shapes (teardrops, artwork): 8 on TOP

## Text on the board
Ref Des/Silkscreen Bottom: SMART CARD | Rev.C | B | C | MB1144
Ref Des/Silkscreen Top: PSU_E5V | NFC | PSU | STPMS2_in | uSD | U5V | STIk | Mic_L | D5V | CAN | CAN terminal | 5V | FAULT | VBUS | GND | IDD | COM | Bat | MCU | VDD | PG13 | PG12 | PG14 | PG15 | PG10 | PG11 | CAN-RS | PA13 | PA12 | PF4 | PD0 | PD5 | PD7 | PF0 | PG2 | PD3 | PG6 | PG8 | CODEC | MICBIAS | 3V6 | BOOT0 | VDD_MCU | +3V3 | PG3 | PG4 | PD1 | PD4 | PG9 | PG7 | PA11 | PA14 | PG5 | PD6 | PF1 | PC13 | PF2 | PF3 | PF5 | PB6 | 0 <--> 1 | OTG_FS | VDD_USB | COMP2_OUT | VDD_ADJ | BL_BOOT0 | 0=Flash | 1=Sys mem | VDD_IO | AUX2 | AUX1 | PB15 | 1V8 | Motor control | ADC/DAC | VREF+ | PE14 | PE12 | PE10 | PE8 | PG1 | PB2 | PF12 | PF11 | PE4 | PE5 | PC14 | PF6 | PF9 | PF10 | PH1 | PA5 | PA0 | VDDA | Mic_R | PF7 | PF8 | RESET# | PH0 | PC3 | PA4 | PE15 | PE13 | PE11 | PE9 | PE7 | PG0 | PF15 | PF14 | PF13 | PE6 | PC15 | TFT | TRACE | Oap/ADC | Pot | BL_RESET | ST-LINK/V2-1 | STLK OVRCR | PWR_EXT | OA1_OUT | Audio_out1 | Audio_out2 | LDR | Comp | RF_EEPROM | USART1 | JTAG | PD2 | PA9 | PC12 | PA8 | PA10 | PC11 | PC10 | PB9 | PB11 | PB7 | PB10 | PC4 | PB5 | PC5 | PB14 | PC6 | PB13 | PC7 | PB12 | PC8 | PA15 | PC9 | PB8 | PD8 | PD9 | PD10 | PC2 | PD11 | PC1 | PD12 | PC0 | PD13 | PA3 | PD14 | PA2 | PD15 | PB0 | PE0 | PA7 | PE1 | PA6 | PB4 | PE2 | PB3 | PE3 | PB1 | PA1 | IrDA | RS232 | IRDA | USB_PWR | DMIC | VLCD input | NOR_F_WP | S | C | MB1144 Rev.C | Reset | Wkup/Tamper | Joystick | ADC_channel | STM32L476G-EVAL
User.7: C
User.23: 1,4
User.32: U1
User.35: BOOT0 | BOOT1 | 0 <--> 1 | TP1 | 5V | CN2 | CN1 | JP4 | CN3 | U1 | U2 | C6 | C5 | IRDA | C3 | R3 | R4 | C8 | R5 | C4 | MIC+ | TP2 | C9 | R6 | RS232 | C7 | D5V | LD9 | C11 | RV2 | C10 | C1 | Z1 | RV1 | U3 | PC15 | CN4 | R11 | C15 | JP5 | TP5 | 3V3 | TP4 | 3V6 | VDD_ADJ | PC14 | PA4 | GND | PB2 | PF12 | PF14 | PG0 | PE7 | VLCD | PE9 | PE11 | PE13 | PE5 | PG2 | R15 | PF5 | PF3 | PF1 | PE6 | C13 | C12 | TP3 | L1 | R24 | R23 | R22 | R21 | CN5 | R19 | R20 | R17 | R18 | R16 | 41 | C17 | C18 | C19 | C20 | 1 | C14 | R14 | 2 | 42 | U10 | L2 | CN6 | CN7 | PF11 | PF13 | PG1 | PE8 | PE10 | PE12 | PE14 | PE15 | PF0 | PF4 | PF2 | U9 | PE4 | PF15 | RV3 | U8 | R25 | JP6 | U5 | U6 | C33 | C30 | JP7 | C28 | R35 | TP6 | VREF+ | R34 | C31 | C34 | LD6 | JP8 | R30 | ADC/DAC | R38 | R39 | D1 | U7 | C43 | C37 | LD7 | R42 | X1 | CN8 | R41 | LD8 | PB14 | R48 | R47 | R46 | C41 | C40 | R50 | R51 | U16 | U14 | U13 | U15 | C50 | C52 | U17 | R49 | JP9 | B1 | C53 | C56 | C49 | R65 | LD4 | R68 | C55 | LD3 | JP10 | C60 | R64 | R63 | C58 | R62 | CN9 | LD2 | C54 | R75 | R76 | C59 | JP11 | LD1 | OA2_OUT | C62 | T1 | C65 | TP7 | C67 | C66 | X2 | R81 | C71 | U20 | U21 | C74 | SB7 | RV4 | SW1 | R83 | 0 | C75 | C82 | SB11 | SW2 | C76 | U23 | R89 | R88 | X | X3 | R101 | R93 | SB10 | R91 | R99 | U18 | C69 | C81 | BOOT | User Flash | System memory | SRAM | C85 | JP12 | U24 | SMB | R98 | C86 | U25 | R113 | R111 | C98 | C90 | R102 | C89 | C88 | U26 | R112 | C92 | C100 | R123 | R122 | C101 | R121 | C103 | JP14 | SB9 | C94 | PG10 | PB7 | PG15 | PG13 | PC13 | PA14 | PA12 | PA11 | RST | PD7 | PD5 | PD1 | PH0 | PH2 | PG7 | PF6 | PF8 | PG4 | CN10 | B2 | CN11 | JP2 | R129 | R128 | R127 | R126 | R125 | LD5 | T3 | PG8 | PG6 | PF7 | PF9 | PG5 | PG3 | PB6 | PG14 | PG12 | PG11 | PG9 | PD6 | PD4 | PD3 | PD0 | VDD | PH1 | T5 | R132 | PA13 | U27 | R136 | R151 | R150 | R131 | R149 | R168 | R153 | R152 | R144 | R142 | R133 | R141 | R140 | R138 | C105 | TR1 | R167 | CN12 | CN14 | CN13 | TP8 | 2V5 | T4 | R165 | CN15 | C106 | R160 | R158 | R155 | E2PROM RF | CN16 | R159 | TR2 | R157 | TP9 | R161 | JTAG | LDR | USB | PF10 | PA0 | PA5 | PA9 | PA8 | PA10 | PB9 | PB11 | PB10 | PB5 | PB13 | PB12 | PA15 | PB8 | PB15 | PC2 | PC1 | PC0 | PA3 | PA2 | PB0 | PA7 | PA6 | PB4 | PB3 | PB1 | JP1 | C2 | R1 | R2 | R9 | R7 | R8 | R10 | R12 | R13 | C16 | U4 | C21 | C22 | PD2 | C23 | C26 | C25 | C24 | PC12 | C27 | R27 | R28 | R26 | MIC_INN | SG1 | C29 | PC11 | R31 | R33 | R32 | PC10 | R36 | ADC_DAC | LPF | PC3 | C35 | R40 | L3 | PC4 | R37 | C36 | MIC_INP | SG0 | U11 | R44 | R43 | C39 | C38 | PC5 | C45 | C46 | SB1 | C44 | C48 | C47 | PC6 | C42 | R45 | R54 | PC7 | R53 | R52 | C51 | PC8 | R55 | R58 | R60 | R56 | PC9 | NOR_F_WP | R57 | SB2 | R67 | R61 | R59 | IDD | PD8 | C57 | SB3 | R71 | R66 | PD9 | R69 | SB4 | BL_BT0 | R74 | R70 | D2 | R72 | PD10 | R73 | SB5 | U19 | R79 | R77 | PD11 | SB6 | R78 | R80 | C64 | R84 | C72 | C61 | PD12 | C63 | C70 | C73 | U22 | C68 | PD13 | R85 | R82 | R92 | C79 | PD14 | C78 | C77 | R86 | R87 | C80 | T2 | R100 | PD15 | R97 | R95 | C83 | OA2_IN | SB8 | R94 | R96 | C84 | PE0 | R90 | R104 | C87 | C91 | R103 | JP13 | R107 | C97 | R106 | PE1 | R105 | C93 | C96 | R109 | COM | R110 | PE2 | _IN+ | C95 | R108 | R117 | C99 | R115 | R116 | R118 | PE3 | _IN- | C102 | R119 | R114 | ADC | RS1 | R120 | PA1 | C104 | R124 | 48 | 47 | R130 | R137 | R139 | R147 | R146 | R145 | R143 | R164 | R156 | R148 | R135 | R154 | R134 | R166 | R162 | R163 | PSU | USART1 | uSD | - | DC5V | Micro | LDR_OUT | TRST | ST-LINK/V2 | Audio OUT | IrDA | U5V | STlk | power source | VDD>2.2V | 2.2V>VDD>1.8V | VDD<1.8V | + | S | B | 3 | 4 | .
User.37: CN2 | CN1 | 1
User.41: FIGURE | SIZE | 6.0 | 8.0 | 10.0 | 12.0 | 25.0 | 30.0 | 36.0 | 38.0 | 40.0 | 48.0 | 53.0 | 95.0 | 28.0 | 39.0 | 47.0 | 58.0 | 59.0 | 79.0 | 87.0 | 134.0 | 138.0 | 33.0x30.0 | 59.0x33.0 | 126.0x40.0 | 140.0x50.0 | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | +5.0/-5.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | ROTATION | - | 90.000 | 0.000 | QTY | 23 | 6 | 767 | 547 | 2 | 12 | 156 | 18 | 128 | 3 | 1 | 7 | 4 | 1708 | TOTAL HOLES:

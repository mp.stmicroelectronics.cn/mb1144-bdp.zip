# Allegro board MB1144.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD_ADJ: length 204.3
  TOP w0.508: v3(50.01,30.86) 51.66,32.51 51.66,38.99 46.58,44.07 30.83,44.07 28.92,45.97 22.45,45.97 v3(21.94,46.48) ; 44.56,21.97 C131.1 ; C131.1 45.31,22.78 ; C131.1 45.31,21.16 ; 45.65,19.01 U34.4 45.12,18.6 ; R236.1 44.49,19.18 ; R236.1 43.91,19.75 ; R236.1 43.33,19.18 ; C133.1 45.69,20.78 ; C133.1 45.69,19.86 ; C133.1 45.23,20.32 ; v3(20.97,130.3) 21.48,130.81 21.48,134.47 22.07,135.05 22.07,139.32 30.96,148.21 30.96,154.81 32.23,156.08 36.16,156.08 JP2.3
  BOTTOM w0.508: v3(50.01,30.86) 45.94,26.8 45.94,24.26 v3(45.43,23.75) v3(44.67,23.75) v3(43.91,23.75) 37.56,17.4 TP13.1 ; v3(20.97,130.3) 20.8,130.12 20.8,117.98 17.62,114.81 17.62,112.9 12.03,107.31 12.03,90.93 17.24,85.72 17.24,77.72 15.84,76.33 15.84,69.98 14.57,68.71 14.57,65.02 23.21,56.39 23.21,49.15 21.94,47.88 v3(21.94,46.48)
VDD_IO: length 93.7
  TOP w0.254: C35.2 62.22,143.48 62.22,141.45 61.25,140.48 U7.95
  TOP w0.279: C46.1 51.66,125.98 51.82,126.15 U7.131
  TOP w0.508: C35.2 61.82,144.02 v1(62.33,144.53) ; C46.1 48.1,125.73 47.47,125.09 43.4,125.09 41.88,123.57 v1(41.88,121.41) ; v1(36.29,117.22) 34.26,119.25 34.26,124.71 33.75,125.22 33.75,131.32 39.97,137.54 v1(39.97,141.1) ; v1(44.04,142.11) 44.04,147.83 46.32,150.11 49.12,150.11 JP3.2 TP4.1 v1(58.77,152.4)
  BOTTOM w0.508: v1(41.88,121.41) 41.88,121.28 41.37,120.78 38.83,120.78 36.29,118.24 v1(36.29,117.22) ; v1(39.97,141.1) 40.99,142.11 v1(44.04,142.11) ; v1(58.77,152.4) 58.77,147.45 59.66,146.56 62.07,146.56 62.45,146.18 62.45,144.65 v1(62.33,144.53)
VDD_MCU: length 80.4
  TOP w0.254: C43.2 50.26,130.94 51.66,130.94 51.87,131.15 U7.121 ; C48.2 47.99,119.65 U7.144 ; C38.2 66.75,141.75 U7.84
  TOP w0.279: U7.17 62.75,116.76 C51.2 ; U7.39 75.41,120.65 ; U7.108 54.75,139.91 54.32,140.34 54.32,141.6 ; U7.52 75.3,127.15 75.79,127.64 76.17,127.64 ; C42.1 77.82,131.7 77.37,132.14 75.09,132.14 75.09,132.15 U7.62 ; U7.72 76.41,137.15 77.69,138.43 C41.2
  TOP w0.508: C48.2 v3(47.85,118.36) ; v3(76.3,128.78) 76.3,127.76 76.17,127.64 ; v3(62.71,115.82) 62.07,115.82 C51.2 ; v3(33.3,105.71) 33.3,105.54 33.05,105.28 23.72,105.28 JP11.2 JP11.3 ; 54.32,141.6 53.05,142.88 C32.1 v3(51.91,143.89) ; C41.2 78.96,138.56 v3(79.6,139.19) ; C43.2 49.37,131.06 v3(49.12,130.81) ; C38.2 v3(65.5,140.72) ; C42.1 78.71,132.21 v3(78.45,132.46) ; v3(79.09,117.6) C50.2 77.57,118.49 75.41,120.65 75.41,120.65
  BOTTOM w0.508: v3(47.85,118.36) 47.85,117.23 45.66,115.03 41.15,115.03 33.3,107.19 v3(33.3,105.71)
VDD_USB: length 39.5
  TOP w0.254: U7.106 55.72,139.23 55.72,140.21 55.59,140.34 55.59,140.97
  TOP w0.508: 55.59,140.97 55.47,141.1 C36.2 C33.1 v1(54.32,143)
  BOTTOM w0.508: TP2.1 JP1.2 36.8,158.17 38.28,156.68 41.28,156.68 42.01,155.96 42.01,148.21 47.21,143 v1(54.32,143)
VDDA: length 39.9
  TOP w0.279: v3(72.74,119.38) 71.52,119.38 70.75,118.61 U7.33
  TOP w0.508: 91.79,105.71 L1.2 ; L1.2 91.17,106.3 ; L1.2 91.79,106.88 ; 88.36,107.39 C59.1 ; C59.1 88.36,109.27 ; C59.1 87.55,108.33 ; C59.1 89.17,108.33 ; C60.2 87.6,106.63 ; C60.2 88.06,106.17 ; C60.2 87.6,105.71 ; 91.15,108.28 TP8.1 ; TP8.1 91.15,110.16 ; TP8.1 92.09,109.22 ; TP8.1 90.21,109.22 ; 87.29,111.25 CN10.2 ; CN10.2 88.23,110.31 ; CN10.2 88.23,112.19 ; CN10.2 89.17,111.25
  BOTTOM w0.508: v3(72.74,119.38) 72.87,119.25 86.33,119.25 86.84,118.75 86.84,114.81 88.23,113.41 CN10.2
A0: length 208.7
  TOP w0.102: U5.E2 102.45,143.61 102.97,143.1 102.97,142.72 v4(102.84,142.6)
  TOP w0.127: U21.47 53.39,70.44 52.67,69.72 51.78,69.72 51.02,70.48 35.66,70.48 v1(35.53,70.61) ; v1(59.65,130.87) 58.9,130.12 58.9,127.13 59.25,126.77 U7.10 ; CN6.25 v1(28.16,121.41) ; v1(80.92,153.37) 80.92,153.31 81.6,152.63 82.61,152.63 82.94,152.3 U2.A3
  BOTTOM w0.127: v1(35.53,70.61) 34,72.14 33.5,72.14 30.68,74.95 30.68,76.48 29.76,77.39 29.76,90.5 27.07,93.19 27.07,94.67 26.48,95.25 26.48,97.76 26.77,98.04 26.77,100.6 27.74,101.57 27.74,110.53 26.64,111.63 26.64,119.89 v1(28.16,121.41) 28.82,122.07 32,122.07 39.08,129.16 44.04,129.16 44.29,129.41 46.58,129.41 46.96,129.03 57.81,129.03 v1(59.65,130.87) 60.6,131.83 66.74,131.83 71.09,136.17 71.09,136.78 72.84,138.53 73.73,138.53 77.31,142.11 77.31,150.75 79.34,152.78 80.36,152.78 80.87,153.29 80.87,153.31 v1(80.92,153.37) 80.92,153.44 81.12,153.64 81.12,154.18 82.14,155.19 83.61,155.19 84.22,154.58 88.77,154.58 89,154.81 89,157.15 91.99,160.15 97.12,160.15 99.92,157.35 99.92,154.25 101.34,152.83 101.34,149.83 102.86,148.31 102.86,143.73 102.97,143.62 102.97,142.72 v4(102.84,142.6)
A0_1DELAY: length 12.5
  TOP w0.127: U21.2 53.39,65.32 v1(52.67,66.04) ; v1(56.61,69.82) 56.61,69.82 56.89,70.1 U21.40
  BOTTOM w0.127: 52.42,63.63 52.04,64.01 52.04,65.41 v1(52.67,66.04) 56.36,69.72 56.51,69.72 v1(56.61,69.82)
A0_2DELAY: length 3.8
  TOP w0.127: v1(56.48,62.31) 56.48,62.36 56.89,62.77 U21.9
  BOTTOM w0.127: 54.71,63.27 54.71,63.12 55.52,62.31 v1(56.48,62.31)
A1: length 225.2
  TOP w0.102: U5.D2 101.44,144.06 100.98,143.6 100.98,142.88 101.37,142.49 v4(101.77,142.49)
  TOP w0.127: v1(59.65,130.17) 59.28,129.8 59.28,127.38 59.75,126.91 U7.11 ; v1(81.55,153.37) 81.91,153.01 82.92,153.01 U2.A4 ; CN6.26 v1(29.56,121.41) ; v1(59.15,69.6) 58.39,70.35 U21.37 ; v1(39.62,67.79) 43.15,64.26 48.41,64.26 52.04,60.63 58.29,60.63 58.72,61.06 v1(58.72,62.15)
  BOTTOM w0.127: v1(58.72,62.15) 58.13,62.74 58.13,64.14 SB51.1 58.9,67.56 59.15,67.82 v1(59.15,69.6) ; v4(101.77,142.49) 101.77,142.6 101.8,142.62 101.8,143.54 102.58,144.32 102.58,148.08 100.96,149.71 100.96,152.65 99.54,154.08 99.54,157.18 96.95,159.77 92.17,159.77 89.38,156.97 89.38,156.26 89.25,156.13 89.25,155.63 89.22,155.6 89.22,154.71 88.82,154.31 84.04,154.31 83.41,154.94 82.9,154.94 82.77,154.81 82.39,154.81 81.76,154.18 81.76,153.62 81.55,153.42 v1(81.55,153.37) 81.5,153.31 81.5,153.29 80.61,152.4 79.6,152.4 77.69,150.5 77.69,141.94 73.91,138.15 73.02,138.15 71.6,136.73 71.6,136.42 71.62,136.4 71.62,136.09 66.97,131.44 60.92,131.44 v1(59.65,130.17) 58.13,128.65 46.7,128.65 46.32,129.03 44.8,129.03 44.55,128.78 39.34,128.78 31.97,121.41 v1(29.56,121.41) 28.92,121.41 27.02,119.51 27.02,111.89 28.12,110.79 28.12,101.3 27.15,100.33 27.15,97.79 26.86,97.51 26.86,95.41 27.45,94.82 27.45,93.37 30.14,90.68 30.14,77.56 31.12,76.58 31.12,75.27 33.75,72.64 34.77,72.64 v1(39.62,67.79)
A1_1DELAY: length 4.5
  TOP w0.127: v1(59.89,65.81) 58.74,65.81 58.39,65.46 U21.12
  BOTTOM w0.127: v1(59.89,65.81) 60.29,65.41 SB50.1
A1_BUF: length 31.2
  TOP w0.127: U22.24 82.68,65.12 82.39,65.41 71.85,65.41 71.18,64.73 U22.1 71.18,62.58 R166.2 68.75,62.1 67.05,60.4 62.5,60.4 v1(61.94,60.96)
  BOTTOM w0.127: 58.9,63.37 61.61,63.37 61.94,63.04 v1(61.94,60.96)
A2: length 129
  TOP w0.102: v4(99.92,143.59) 99.96,143.62 99.99,143.62 100.43,144.06 U5.C2 ; U2.A5 82.41,153.78 v1(82.26,153.92)
  TOP w0.127: v1(61.31,130.81) 61.18,130.81 60.25,129.88 U7.12 ; CN6.32 v1(29.43,117.6)
  BOTTOM w0.127: v4(99.92,143.59) 99.94,143.59 99.98,143.62 101.43,143.62 102.2,144.4 102.2,147.96 99.97,150.19 99.97,151.76 99.16,152.58 99.16,157 96.77,159.38 92.35,159.38 89.76,156.79 89.76,156.08 89.63,155.96 89.63,155.45 89.5,155.32 89.5,154.56 88.97,154.03 83.94,154.03 83.79,154.18 82.52,154.18 v1(82.26,153.92) 82.26,153.03 81.88,152.65 81.5,152.65 80.87,152.02 79.98,152.02 78.07,150.11 78.07,141.76 74.09,137.77 73.2,137.77 72,136.58 72,135.92 67.15,131.06 61.56,131.06 v1(61.31,130.81) 60.93,130.81 58.39,128.27 52.93,128.27 51.86,127.2 40.05,127.2 30.45,117.6 v1(29.43,117.6)
A3: length 130.5
  TOP w0.102: v4(97.99,143.61) 98,143.61 U5.A2
  TOP w0.127: v1(81.96,152.17) 82.24,151.89 83.15,151.89 83.41,152.15 83.56,152.15 U2.B3 ; v1(61.31,130.18) 60.75,129.61 U7.13 ; CN6.34 v1(29.43,116.33)
  BOTTOM w0.127: v4(97.99,143.61) 98.44,143.15 99.13,143.15 99.4,143.42 99.4,143.68 99.76,144.04 100.5,144.04 100.65,143.89 101.37,143.89 101.9,144.42 101.9,147.5 99.59,149.81 99.59,151.59 98.77,152.4 98.77,156.82 96.59,159 92.53,159 90.14,156.62 90.14,155.91 90.01,155.78 90.01,155.37 89.73,155.09 89.73,154.46 89,153.72 83.51,153.72 v1(81.96,152.17) 81.63,152.17 81.1,151.64 80.16,151.64 78.45,149.94 78.45,141.58 74.26,137.39 73.37,137.39 72.38,136.4 72.38,135.74 67.33,130.68 61.82,130.68 v1(61.31,130.18) 60.93,130.18 58.64,127.89 53.69,127.89 51.78,125.98 50.51,125.98 50.13,125.6 39.72,125.6 30.45,116.33 v1(29.43,116.33)
A4: length 127.3
  TOP w0.102: v5(83.33,152.65) 83.41,152.65 83.69,152.94 U2.B4 ; U5.B2 v4(98.99,143.6)
  TOP w0.127: v1(61.31,129.54) 61.25,129.48 U7.14 ; v1(28.29,114.68) 27.4,113.79 CN6.37
  BOTTOM w0.127: v4(98.99,143.6) 99.76,144.37 100.5,144.37 100.76,144.12 101.26,144.12 101.64,144.5 101.64,147.36 99.21,149.8 99.21,151.41 98.39,152.22 98.39,156.64 96.41,158.62 92.7,158.62 90.52,156.44 90.52,155.73 90.39,155.6 90.39,155.19 90.04,154.84 90.04,154.43 89,153.39 84.07,153.39 v5(83.33,152.65) 83.08,152.65 82.14,151.71 81.73,151.71 81.27,151.26 80.33,151.26 78.84,149.76 78.84,141.4 67.74,130.3 62.07,130.3 v1(61.31,129.54) 59.28,127.51 53.94,127.51 51.28,124.84 40.23,124.84 30.19,114.81 28.42,114.81 v1(28.29,114.68)
A5: length 121.8
  TOP w0.102: v5(84.84,152.65) 84.47,152.28 U2.C3
  TOP w0.127: v1(62.07,129.54) 61.75,129.22 U7.15 ; v1(29.81,114.3) 30.32,113.79 CN6.38 ; U5.D3 101.45,145.04 v4(100.93,144.53)
  BOTTOM w0.127: v4(100.93,144.53) 101.39,144.98 101.39,147.19 98.83,149.76 98.83,151.23 98.01,152.04 98.01,156.46 96.23,158.24 92.88,158.24 90.9,156.26 90.9,155.37 90.32,154.79 90.32,154.31 89.12,153.11 85.3,153.11 v5(84.84,152.65) 84.17,152.65 83.71,152.2 83.03,152.2 82.16,151.33 81.91,151.33 81.45,150.88 80.51,150.88 79.22,149.58 79.22,141.22 67.91,129.92 62.45,129.92 v1(62.07,129.54) 59.66,127.13 54.1,127.13 51.43,124.46 40.61,124.46 30.45,114.3 v1(29.81,114.3)
A6: length 98.6
  TOP w0.102: v1(97.12,144.02) 97.35,144.25 97.91,144.25 98.11,144.45 99.4,144.45 100,145.06 U5.C3
  TOP w0.127: v4(81.4,148.03) 81.5,148.03 82.52,149.05 82.52,150.85 82.8,151.13 83.04,151.13 83.34,151.43 83.34,151.68 83.55,151.88 83.79,151.88 84.07,152.16 84.07,152.43 84.44,152.8 U2.C4 ; CN7.17 v1(97.12,126.49) ; U7.50 72.73,126.15 71.98,126.9 v1(71.98,128.52)
  BOTTOM w0.127: v1(97.12,144.02) 96.92,144.22 96.92,147.96 96.11,148.77 96.11,155.57 95.35,156.34 93.77,156.34 92.81,155.37 92.81,154.48 92.27,153.95 92.27,153.72 89.94,151.38 87.42,151.38 87.04,151 85.82,151 85.69,151.13 84.55,151.13 84.17,150.75 84.17,150.62 81.58,148.03 v4(81.4,148.03) 81.12,147.75 81.12,138.73 79.75,137.36 78.15,137.36 73.6,132.82 73.6,132.51 73.63,132.49 73.63,131.44 71.98,129.79 v1(71.98,128.52) 72.1,128.4 72.74,128.4 73.25,127.89 74.9,127.89 75.41,127.38 90.77,127.38 91.66,126.49 v1(97.12,126.49)
A7: length 101.6
  TOP w0.102: v4(97.5,145.03) 97.53,145.06 U5.A3
  TOP w0.127: U7.53 74.29,127.64 72.87,127.64 v1(72.61,127.89) ; CN7.18 v1(98.27,126.49) ; v1(81.25,149.28) 81.22,149.3 81.22,150.14 79.09,152.27 79.09,153.92 79.34,154.18 81.38,154.18 82.14,153.42 84.68,153.42 85.06,153.03 U2.D4
  BOTTOM w0.127: v1(98.27,126.49) 97.63,125.86 91.66,125.86 90.52,127 75.15,127 74.64,127.51 72.99,127.51 v1(72.61,127.89) 71.98,127.89 71.29,128.57 71.29,131.06 78.09,137.86 79.41,137.86 80.11,138.56 80.11,139.4 80.74,140.03 80.74,148.87 81.15,149.28 v1(81.25,149.28) 81.32,149.35 82.34,149.35 83.38,150.39 83.41,150.39 84.4,151.38 85.82,151.38 85.95,151.26 86.71,151.26 87.22,151.76 89.76,151.76 91.89,153.9 91.89,154.13 92.42,154.66 92.42,155.55 93.59,156.72 95.52,156.72 96.49,155.75 96.49,151.26 97.4,150.34 97.4,145.14 v4(97.5,145.03)
A8: length 76.7
  TOP w0.102: 96.87,147.59 98,147.59 98.11,147.47 98.86,147.47 U5.B6
  TOP w0.127: U2.H2 88.34,151.38 88.84,151.38 v4(89.3,150.93) 89.48,150.75 89.77,150.75 91.04,149.48 94.15,149.48 96.04,147.59 96.87,147.59 ; U7.54 74.3,128.14 73.37,128.14 72.49,129.03 v1(72.49,129.41) ; CN7.16 v1(98.14,127.76)
  BOTTOM w0.127: v1(98.14,127.76) 97.5,127.13 91.66,127.13 91.03,127.76 75.66,127.76 75.15,128.27 73.5,128.27 72.49,129.29 v1(72.49,129.41) 72.49,129.67 74.01,131.19 74.01,132.66 78.33,136.98 79.93,136.98 81.54,138.6 81.54,147.43 84.73,150.62 88.69,150.62 88.82,150.75 89.12,150.75 v4(89.3,150.93)
A9: length 74.8
  TOP w0.127: CN7.14 98.37,129.03 98.16,128.83 v1(98.16,128.73) ; U5.A6 98.05,148.45 96.42,148.45 94.63,150.24 91.62,150.24 90.75,151.12 v4(90.75,151.33) 90.53,151.33 89.59,152.27 88.2,152.27 U2.H3 ; v1(73.12,129.41) 73.12,129.03 73.51,128.65 U7.55
  BOTTOM w0.127: v4(90.75,151.33) 89.78,150.37 88.55,150.37 87.89,149.71 84.73,149.71 84.7,149.73 84.4,149.73 82.26,147.6 82.26,138.76 80.11,136.6 78.71,136.6 74.39,132.28 74.39,130.94 73.12,129.67 v1(73.12,129.41) 73.12,129.29 73.63,128.78 75.28,128.78 75.91,128.14 96.04,128.14 96.17,128.27 97.71,128.27 v1(98.16,128.73)
A10: length 75.1
  TOP w0.102: 96.87,149.47 99.59,149.47 99.84,149.21 99.84,148.67 U5.C6
  TOP w0.127: CN7.12 98.55,130.3 v1(98.14,129.9) ; U2.H4 88.35,153.03 88.44,153.11 89.33,153.11 89.35,153.14 90.52,153.14 91.97,151.69 v4(91.97,151.1) 92.07,151 95.19,151 96.73,149.47 96.87,149.47 ; U7.56 v1(75.53,129.15)
  BOTTOM w0.127: v4(91.97,151.1) 91.97,151.05 90.9,149.99 88.72,149.99 88.06,149.33 84.55,149.33 82.65,147.42 82.65,138.58 80.28,136.22 78.89,136.22 74.77,132.11 74.77,129.79 75.42,129.15 v1(75.53,129.15) 75.65,129.15 75.79,129.29 97.53,129.29 v1(98.14,129.9)
A11: length 85.6
  TOP w0.102: 101.49,151.13 101.49,150.93 101.83,150.58 101.83,148.44 U5.D6
  TOP w0.127: v1(76.17,129.92) 76.04,129.92 75.79,129.67 74.9,129.67 74.88,129.65 U7.57 ; U2.H5 88.34,153.92 90.85,153.92 92.91,151.87 93.19,151.87 v4(93.21,151.84) 95.78,151.84 98.34,154.41 98.34,154.43 98.37,154.46 98.37,154.74 98.34,154.76 98.34,155.14 99.38,156.18 102.69,156.18 102.99,155.88 102.99,155.52 101.49,154.03 101.49,151.13 ; v1(96.79,129.92) 96.41,130.3 CN7.11
  BOTTOM w0.127: v1(96.79,129.92) v1(76.17,129.92) 75.15,130.94 75.15,131.93 79.06,135.84 80.46,135.84 83.03,138.4 83.03,147.24 84.73,148.95 88.23,148.95 88.89,149.61 91.13,149.61 93.21,151.69 v4(93.21,151.84)
A12: length 112.9
  TOP w0.102: 89,151.89 87.81,151.89 87.44,152.26 U2.G3 ; U5.B7 98.89,148.5 98.89,147.96 98.61,147.68 98.22,147.68 97.91,147.98 96.87,147.98
  TOP w0.127: 96.87,147.98 96.31,147.98 94.43,149.86 91.37,149.86 v1(90.65,150.58) 89.34,151.89 89,151.89 ; v1(86.71,158.62) 87.22,158.12 92.68,158.12 94.58,156.21 v1(94.58,155.88) ; v1(65.69,137.86) 65.25,138.3 U7.87 ; CN6.13 v1(28.42,129.03)
  BOTTOM w0.127: v1(94.58,155.88) 94.58,155.65 93.57,154.64 93.57,154.13 93.03,153.59 93.03,153.37 92.04,152.37 92.04,151.82 90.81,150.58 v1(90.65,150.58) ; v1(86.71,158.62) 86.2,158.12 79.98,158.12 79.72,157.86 79.22,157.86 78.96,158.12 77.95,158.12 74.9,155.07 74.9,145.19 74.42,144.7 74.42,144.17 73.37,143.13 73.37,143 69.31,138.94 66.77,138.94 v1(65.69,137.86) 65.25,137.41 65.25,135.51 64.1,134.37 58.13,134.37 58.01,134.49 37.69,134.49 32.73,129.54 28.92,129.54 v1(28.42,129.03)
A13: length 107.6
  TOP w0.127: U5.A7 96.53,149.06 94.96,150.62 91.79,150.62 91.54,150.88 91.54,151.46 v1(91.28,151.71) 91.28,151.82 90.34,152.76 88.56,152.76 88.47,152.67 87.8,152.67 U2.G4 ; v1(29.56,130.05) 29.81,130.3 CN6.12 ; v1(64.93,137.97) 64.75,138.15 U7.88 ; v1(93.95,155.85) 93.95,156.08 92.3,157.73 86.96,157.73 86.07,158.62 v1(85.69,158.62)
  BOTTOM w0.127: v1(85.69,158.62) 85.31,159 82.14,159 81.76,159.38 78.45,159.38 74.52,155.45 74.52,145.36 74.03,144.88 74.03,144.42 72.99,143.38 72.99,143.26 69.18,139.45 66.4,139.45 v1(64.93,137.97) 64.87,137.91 64.87,135.76 63.85,134.75 58.39,134.75 58.26,134.87 37.43,134.87 32.61,130.05 v1(29.56,130.05) ; v1(93.95,155.85) 93.92,155.83 93.92,155.8 93.19,155.07 93.19,154.31 92.65,153.77 92.65,153.54 91.28,152.17 v1(91.28,151.71)
A14: length 118
  TOP w0.127: v1(65.73,137.1) 65.5,137.33 64.88,137.33 64.25,137.96 U7.89 ; v1(101.62,155.73) 100.2,155.73 98.65,154.18 98.65,152.22 99.92,150.95 99.92,150.01 100.43,149.5 100.43,149.08 U5.C7 ; v1(85.44,157.61) 84.93,157.1 84.93,155.83 84.55,155.45 84.55,155.07 84.8,154.81 84.8,153.67 85.06,153.42 85.31,153.42 85.57,153.16 85.57,152.91 85.82,152.65 86.32,152.65 U2.F3 ; CN6.14 v1(29.56,129.03)
  BOTTOM w0.127: v1(29.56,129.03) 32.86,129.03 37.94,134.11 57.75,134.11 57.88,133.99 64.36,133.99 65.73,135.36 v1(65.73,137.1) 65.73,137.19 67.1,138.56 69.56,138.56 72.08,141.07 72.76,141.07 74.8,143.1 74.8,144.53 75.28,145.01 75.28,153.67 78.07,156.46 78.96,156.46 80.23,157.73 85.31,157.73 v1(85.44,157.61) 86.33,157.61 86.84,158.12 87.73,158.12 91.15,161.54 97.96,161.54 101.44,158.06 101.44,155.93 101.62,155.75 v1(101.62,155.73)
A15: length 108
  TOP w0.102: 96.87,149.99 96.95,149.91 97.96,149.91 98.2,149.67 99.83,149.67 100.04,149.45 100.04,148.87 100.3,148.62 101.01,148.62 U5.D7
  TOP w0.127: v1(33.5,132.33) 32.73,131.57 CN6.10 ; U7.90 63.72,139.22 63.72,139.95 v1(64.23,140.46) ; v1(95.22,155.83) 95.22,156.21 92.93,158.5 87.6,158.5 v1(87.34,158.75) ; U2.F4 86.8,153.03 87.19,153.42 88.33,153.42 88.46,153.54 90.67,153.54 92.42,151.79 v1(92.42,151.56) 92.6,151.38 95.47,151.38 96.87,149.99
  BOTTOM w0.127: v1(95.22,155.83) 95.22,155.73 93.95,154.46 93.95,153.95 93.52,153.52 93.52,153.29 92.42,152.2 v1(92.42,151.56) ; v1(87.34,158.75) 86.71,159.38 82.52,159.38 82.14,159.77 78.2,159.77 74.14,155.7 74.14,145.54 73.65,145.06 73.65,144.68 72.49,143.51 72.49,143.38 70.45,141.35 65.12,141.35 v1(64.23,140.46) 63.85,140.08 63.72,140.08 61.18,137.54 59.66,137.54 57.75,135.64 36.8,135.64 v1(33.5,132.33)
A16: length 142.1
  TOP w0.102: 102.04,150.69 102.04,149.47 U5.E7
  TOP w0.127: v1(86.02,86.74) 85.54,86.26 85.54,84.76 84.47,83.69 72.03,83.69 68.98,80.64 68.58,80.64 ; 102.04,150.69 102.04,153.45 102.03,153.47 102.03,153.87 v1(102.99,154.84) 102.99,154.86 103.37,155.24 103.37,156.06 102.86,156.57 99.21,156.57 97.96,155.32 97.96,154.58 95.65,152.27 93.06,152.27 91.15,154.18 91.15,154.61 90.76,155 89.67,155 89.1,155.57 88.28,155.57 87.79,155.08 87.79,154.37 87.6,154.18 87.34,154.18 87.09,153.92 87.09,153.67 86.84,153.42 86.33,153.42 U2.E4
  BOTTOM w0.127: v1(86.02,86.74) 98.14,86.74 103.85,92.46 103.85,97.71 104.72,98.58 104.72,98.6 105.63,99.52 105.63,108.97 105.25,109.35 105.25,135.89 105.76,136.4 105.76,136.78 106.45,137.46 107.03,137.46 108.88,139.32 108.88,141.12 109.65,141.88 109.65,150.14 108.83,150.95 107.12,150.95 106.69,151.38 105,151.38 103.57,152.81 103.57,153.77 102.99,154.36 v1(102.99,154.84)
A17: length 109.6
  TOP w0.102: U5.B3 99.04,144.65 97.92,144.65 97.77,144.5 96.87,144.5
  TOP w0.127: R151.1 74.36,83.29 84.63,83.29 85.92,84.58 85.92,85.95 86.58,86.61 86.58,88.9 85.95,89.53 v1(85.95,89.66) ; 96.87,144.5 96.84,144.5 94.71,142.37 94.71,142.24 94.08,141.6 93.92,141.6 93.26,142.27 v1(92.02,142.27) 91.94,142.34 90.44,142.34 89.15,143.64 89.15,146.53 86.58,149.1 86.58,150.24 86.33,150.5 86.33,150.91 86.1,151.14 85.81,151.14 85.59,151.36 85.59,151.88 U2.D3
  BOTTOM w0.127: v1(92.02,142.27) 91.99,142.27 91.59,141.86 91.59,141.17 94.84,137.92 98.34,137.92 101.06,135.2 101.06,109.8 100.5,109.25 100.5,101.17 98.65,99.31 98.65,96.52 94.08,91.95 89.63,91.95 88.36,90.68 86.96,90.68 v1(85.95,89.66)
A18: length 110.6
  TOP w0.102: 96.87,145.16 97.15,145.44 99.83,145.44 U5.C4
  TOP w0.127: 73.66,80.64 75.92,82.91 84.8,82.91 86.3,84.4 86.3,85.78 86.96,86.44 86.96,89.28 v1(86.58,89.66) ; 96.87,145.16 95.37,143.66 v1(93.87,143.66) 93.69,143.48 91.79,143.48 91.21,144.07 91.21,147.65 88.49,150.37 88.49,150.4 88.19,150.7 U2.H1
  BOTTOM w0.127: v1(93.87,143.66) 93.49,143.28 93.49,141.81 95.85,139.45 99.05,139.45 102.58,135.92 102.58,108.86 102.05,108.33 102.05,100.18 100.81,98.93 100.81,96.01 98.01,93.22 98.01,91.31 97.5,90.81 93.82,90.81 93.31,90.3 87.22,90.3 v1(86.58,89.66)
A19: length 91.7
  TOP w0.102: 96.87,146.56 96.98,146.44 100.83,146.44 U5.D5
  TOP w0.127: v1(92.93,90.81) 92.93,90.68 92.04,89.79 R139.1 R150.1 ; U2.G2 87.58,151.53 87.98,151.13 88.33,151.13 88.54,150.93 88.54,150.9 91.59,147.85 91.59,145.54 91.79,145.34 v1(92.02,145.34) 92.22,145.34 92.78,145.9 95.57,145.9 96.23,146.56 96.87,146.56
  BOTTOM w0.127: v1(92.02,145.34) 92.2,145.34 92.68,144.86 92.68,141.78 92.65,141.76 92.65,141.38 95.35,138.68 98.7,138.68 101.82,135.56 101.82,109.4 101.26,108.84 101.26,100.66 99.66,99.06 99.66,96.14 94.71,91.19 93.31,91.19 v1(92.93,90.81)
A20: length 93.9
  TOP w0.102: v4(100.91,145.54) 100.93,145.54 U5.D4
  TOP w0.127: U2.H6 88.11,154.61 88.11,155.07 88.39,155.35 88.89,155.35 89.76,154.48 v5(90.71,154.48) ; R100.1 53.94,111.38 R84.1 53.44,111.63 v1(52.42,112.65)
  BOTTOM w0.127: v1(52.42,112.65) 52.29,112.78 52.29,115.7 56.23,119.63 56.23,122.22 59.53,125.53 59.53,126.36 62.71,129.54 68.09,129.54 79.6,141.05 79.6,149.4 80.69,150.5 81.76,150.5 83.18,151.92 83.81,151.92 84.17,152.27 86.2,152.27 86.79,152.86 89.33,152.86 90.71,154.24 v5(90.71,154.48) 90.71,154.62 91.28,155.19 91.28,156.08 93.06,157.86 96.06,157.86 97.63,156.29 97.63,151.87 98.44,151.05 98.44,149.8 100.91,147.33 v4(100.91,145.54)
A21: length 85.9
  TOP w0.102: v4(99.92,147.55) 100.41,147.06 U5.C5 ; v5(86.32,151.92) 86.28,151.96 86.28,151.99 85.99,152.28 U2.E3
  TOP w0.127: v1(54.71,114.43) 54.45,114.17 54.45,112.52 55.21,111.76 R85.1 R101.1
  BOTTOM w0.127: v4(99.92,147.55) 98.05,149.42 98.05,150.89 97.25,151.69 97.25,156.11 95.88,157.48 93.24,157.48 91.66,155.91 91.66,155.02 91.1,154.46 91.1,154.23 89.43,152.55 86.95,152.55 v5(86.32,151.92) 86.21,152.02 84.27,152.02 83.94,151.69 83.56,151.69 81.98,150.11 80.87,150.11 79.98,149.22 79.98,140.87 68.27,129.16 62.96,129.16 59.91,126.11 59.91,125.35 56.61,122.05 56.61,119.25 54.83,117.47 54.83,114.55 v1(54.71,114.43)
A22: length 81.6
  TOP w0.102: U5.B8 98.8,150.71 97.63,150.71 v4(97.52,150.83)
  TOP w0.127: v1(55.85,114.43) 55.98,114.3 55.98,112.39 R86.1 56.74,110.49 R102.1
  BOTTOM w0.127: v4(97.52,150.83) 96.87,151.47 96.87,155.93 95.7,157.1 93.41,157.1 92.04,155.73 92.04,154.84 91.48,154.28 91.48,154.05 89.58,152.15 87.09,152.15 86.46,151.51 86.07,151.51 85.82,151.76 84.35,151.76 84.04,151.46 83.89,151.46 82.16,149.73 81.05,149.73 80.36,149.05 80.36,140.69 68.45,128.78 63.21,128.78 60.29,125.86 60.29,125.17 56.99,121.87 56.99,119 55.47,117.47 55.47,114.81 v1(55.85,114.43)
A23: length 99.2
  TOP w0.127: v1(102.53,155.7) 102.03,155.19 100.22,155.19 99.03,154 99.03,152.7 100.45,151.28 U5.C8 ; v1(90.42,87.5) 89.76,86.84 R138.1 R149.1
  BOTTOM w0.127: v1(102.53,155.7) 102.53,154.25 103.19,153.59 103.19,152.6 104.92,150.88 106.65,150.88 106.95,150.57 108.65,150.57 109.26,149.96 109.26,142.06 108.5,141.3 108.5,139.5 106.85,137.85 106.24,137.85 104.87,136.47 104.87,109.17 105.25,108.79 105.25,99.69 104.34,98.78 104.34,98.76 103.47,97.89 103.47,92.71 99.16,88.39 95.35,88.39 94.46,87.5 v1(90.42,87.5)
AIN_1: length 5.1
  TOP w0.127: R186.2 R183.1 59.66,46.61 60.04,46.99 60.04,48.51 60.32,48.8 U23.10
BL_VDD: length 16.6
  TOP w0.508: v1(94.2,35.69) R259.1 ; L4.1 92.3,31.11 C115.1 94.58,31.11 95.6,32.13 C113.2 v1(96.87,32.13)
  BOTTOM w0.508: CN19.28 99.88,30.99 98.01,30.99 v1(96.87,32.13) 94.2,34.8 v1(94.2,35.69)
BOOT0: length 66.5
  TOP w0.127: v1(57.5,121.03) 55.88,122.65 U7.138 49.66,122.65 v1(48.86,123.44) 47.47,123.44 R67.1 ; CN7.20 v1(98.27,125.22)
  BOTTOM w0.127: v1(48.86,123.44) 43.66,123.44 JP8.1 ; v1(98.27,125.22) 98.01,125.22 97.38,124.59 91.54,124.59 89.88,126.24 79.34,126.24 78.71,125.6 68.8,125.6 66.64,127.76 62.83,127.76 60.67,125.6 60.67,124.99 57.5,121.82 v1(57.5,121.03)
COMP2_INP: length 61.5
  TOP w0.508: 86.36,98.42 87.48,99.54 92.04,99.54 96.01,95.58 v1(108.68,95.58)
  BOTTOM w0.508: v1(108.68,95.58) 108.71,95.58 109.21,96.09 109.21,110.36 107.54,112.04 107.54,113.69 109.59,115.75 109.59,124.23 110.41,125.04 110.41,127.38 110.92,127.89 110.92,128.6 JP7.3
COMP2_OUT: length 11.4
  BOTTOM w0.127: TP6.1 48.05,109.27 48.05,98.63 48.25,98.42 48.26,98.42
D0: length 153.9
  TOP w0.127: v1(82.01,72.39) 82.18,72.22 U22.26 ; 76.2,80.64 76.2,81.31 77.31,82.42 v1(84.25,82.42) 84.96,82.42 86.68,84.15 86.68,85.6 87.47,86.39 v1(87.47,87.88) ; v1(108.3,141.81) 108.1,142.01 108.1,142.02 107.56,142.56 104.2,142.56 103.92,142.84 103.92,143.17 103.63,143.47 103.3,143.47 102.97,143.8 102.97,144.55 102.46,145.06 U5.E3 ; v1(84.93,160.27) 84.93,158.88 83.28,157.23 83.28,155.7 83.69,155.29 U2.B6
  BOTTOM w0.127: v1(84.25,82.42) 84.25,82.04 84.73,81.56 84.73,75.11 v1(82.01,72.39) ; v1(84.93,160.27) 84.93,160.99 85.87,161.93 98.14,161.93 102.08,157.99 102.08,155.19 102.15,155.12 102.15,154.08 102.81,153.42 102.81,152.43 104.74,150.5 106.52,150.5 106.83,150.19 108.48,150.19 108.88,149.78 108.88,142.39 v1(108.3,141.81) 108.1,141.6 108.1,139.65 106.67,138.23 106.06,138.23 104.49,136.65 104.49,108.97 104.87,108.58 104.87,99.87 103.96,98.96 103.96,98.93 103.09,98.07 103.09,93.09 98.9,88.9 95.22,88.9 94.33,88.01 87.6,88.01 v1(87.47,87.88)
D1: length 142.6
  TOP w0.127: U22.27 81.68,71.96 81.25,72.39 v1(81.25,72.52) ; U5.H3 105.76,145.06 105.84,144.98 106.8,144.98 v1(107,145.19) 107,145.34 108.25,146.58 108.25,148.97 107.77,149.45 107.77,150.14 106.88,151.03 106.88,153.26 106.85,153.29 106.85,154.66 105.89,155.63 105.89,157 104.01,158.88 97.94,158.88 95.68,156.62 95.68,155.65 95.37,155.35 93.8,155.35 91.79,157.35 86.71,157.35 85.95,158.12 84.93,158.12 83.66,156.84 83.66,155.96 84.04,155.57 84.04,154.16 84.42,153.78 U2.C5 ; v1(87.98,89.79) 87.98,86.33 87.06,85.42 87.06,83.9 85.11,81.94 v1(82.62,81.94) 79.75,81.94 78.74,80.93 78.74,80.64
  BOTTOM w0.127: v1(82.62,81.94) 82.9,81.66 82.9,74.17 v1(81.25,72.52) ; v1(87.98,89.79) 93.44,89.79 94.08,90.42 97.76,90.42 98.39,91.06 98.39,92.84 101.44,95.89 101.44,98.93 103.35,100.84 103.35,107.57 102.97,107.95 102.97,137.62 105.1,139.75 105.96,139.75 106.57,140.36 106.57,142.39 107.28,143.1 107.28,144.91 v1(107,145.19)
D2: length 233.2
  TOP w0.102: U5.E4 103.07,146.68 103.07,148.31 103.35,148.59 v4(103.98,148.59)
  TOP w0.127: v1(24.38,126.47) 24.4,126.49 CN6.17 v1(28.34,126.49) ; v1(55.21,132.84) 55.21,133.35 53.92,134.65 U7.114 ; U22.29 80.68,72.81 80.94,73.08 80.94,73.63 80.66,73.91 61.41,73.91 60.6,73.1 56.2,73.1 55.87,72.77 53.21,72.77 52.7,72.26 51.35,72.26 50.59,71.5 31.85,71.5 v1(31.13,70.79) ; U2.C6 84.42,154.53 84.3,154.66 v1(84.3,156.59)
  BOTTOM w0.127: v1(24.38,126.47) 24.38,126.24 24.1,125.96 24.1,114.3 23.08,113.28 23.08,111.38 23.59,110.87 23.59,103.5 20.92,100.84 20.92,97.82 22.93,95.81 22.93,92.97 27.73,88.16 27.73,74.6 31.13,71.2 v1(31.13,70.79) ; v1(28.34,126.49) 28.92,127.08 32.81,127.08 38.7,132.97 48.48,132.97 49.12,132.33 50.13,132.33 50.26,132.46 54.2,132.46 54.58,132.84 v1(55.21,132.84) 58.77,132.84 59.15,133.22 65.35,133.22 72.31,140.18 73.02,140.18 75.56,142.72 75.56,144.17 76.04,144.65 76.04,151.51 81.12,156.59 v1(84.3,156.59) 84.55,156.34 85.69,156.34 87.09,157.73 87.98,157.73 91.41,161.16 97.78,161.16 101.06,157.89 101.06,155.65 101.77,154.94 101.77,153.9 102.43,153.24 102.43,152.25 103.35,151.33 103.35,149.22 v4(103.98,148.59)
D3: length 200.5
  TOP w0.127: U22.30 80.18,72.34 v1(80.23,72.39) ; v1(54.45,133.35) 53.65,134.15 U7.115 ; v1(65.5,134.11) 62.58,131.19 62.58,122.94 63.6,121.92 66.52,121.92 68.04,120.4 68.04,120.14 v1(68.17,120.02) ; U2.D5 85.57,154.15 85.57,154.94 85.5,155 85.5,156.78 v1(85.57,156.84) 85.69,156.97 91.59,156.97 93.59,154.97 95.55,154.97 96.06,155.47 96.06,156.44 98.11,158.5 103.83,158.5 105.51,156.82 105.51,155.45 106.47,154.48 106.47,150.88 107.38,149.96 107.38,149.28 107.77,148.89 107.77,146.65 107.18,146.06 105.45,146.06 U5.H4 ; CN6.16 v1(29.69,127.76)
  BOTTOM w0.127: v1(80.23,72.39) 79.47,71.63 74.9,71.63 74.34,72.19 74.34,74.24 77.08,76.99 77.08,82.3 75.28,84.1 75.28,91.19 72.36,94.11 72.36,99.06 74.64,101.35 74.64,105.66 67.02,113.28 67.02,118.36 68.17,119.51 v1(68.17,120.02) ; v1(85.57,156.84) 85.31,157.1 80.99,157.1 75.66,151.76 75.66,144.83 75.18,144.35 75.18,142.93 72.94,140.69 72.26,140.69 66.19,134.62 66.01,134.62 v1(65.5,134.11) 64.99,133.6 54.71,133.6 v1(54.45,133.35) 53.94,132.84 50.01,132.84 49.88,132.72 49.37,132.72 48.74,133.35 38.45,133.35 32.86,127.76 v1(29.69,127.76)
D4: length 175.2
  TOP w0.127: U22.32 79.18,70.19 79.4,69.98 v1(79.47,69.98) ; v1(76.68,130.43) 75.91,130.43 75.63,130.15 U7.58 73.6,130.15 73.5,130.05 72.49,130.05 71.34,128.91 71.34,123.44 72.49,122.3 72.49,121.54 v1(72.74,121.28) ; v1(98.11,131.06) 99.7,131.06 CN7.10 ; U2.E5 86.33,154.17 86.33,154.69 86.46,154.81 86.46,155.19 87.85,156.59 91.41,156.59 92.75,155.24 92.75,154.91 93.44,154.23 v1(94.41,154.23) 94.76,154.58 95.73,154.58 96.44,155.3 96.44,156.24 98.29,158.09 103.68,158.09 105.12,156.64 105.12,155.27 106.09,154.31 106.09,150.7 107,149.78 107,149.1 107.36,148.74 107.36,146.81 107.11,146.56 105.95,146.56 U5.H5
  BOTTOM w0.127: v1(79.47,69.98) 80.74,71.25 82.39,71.25 85.49,74.35 85.49,82.55 79.98,88.06 79.98,103.25 78.07,105.16 78.07,108.97 76.68,110.36 75.66,110.36 71.22,114.81 71.22,116.84 71.72,117.35 71.72,119.25 72.23,119.76 72.23,120.78 v1(72.74,121.28) ; v1(98.11,131.06) 97.58,130.53 96.77,130.53 96.54,130.3 76.8,130.3 v1(76.68,130.43) 76.04,131.06 76.04,132.26 79.24,135.46 80.64,135.46 83.41,138.23 83.41,147.07 84.91,148.56 88.41,148.56 89.07,149.22 91.33,149.22 92.81,150.7 92.81,150.72 93.9,151.82 93.9,153.34 94.33,153.77 94.33,154.15 v1(94.41,154.23)
D5: length 167.7
  TOP w0.102: 103.17,151.13 103.17,150.53 103.07,150.43 103.07,148.65 102.84,148.42 102.84,147.9 102.45,147.52 U5.E5
  TOP w0.127: v1(76.68,131.06) 75.91,131.06 75.5,130.65 U7.59 73.59,130.65 73.5,130.56 73.37,130.56 73.25,130.43 72.23,130.43 70.83,129.03 70.83,123.19 71.22,122.81 71.22,122.56 71.85,121.92 v1(71.85,121.41) ; v1(96.84,131.06) 96.34,131.57 CN7.9 ; U2.F5 86.69,154.03 87.09,154.43 87.09,155.09 88.06,156.06 89.4,156.06 89.78,155.68 91.21,155.68 91.92,154.97 91.92,154.64 93.39,153.16 v1(94.38,153.16) 94.68,153.16 95.19,153.67 95.93,153.67 97.2,154.94 97.2,155.78 98.75,157.33 103.32,157.33 104.16,156.49 104.16,154.79 102.81,153.44 102.81,151.54 103.17,151.18 103.17,151.13 ; v1(78.68,69.98) U22.33
  BOTTOM w0.127: v1(96.84,131.06) 96.74,131.06 96.36,130.68 77.31,130.68 76.93,131.06 v1(76.68,131.06) 76.68,132.08 79.67,135.08 80.82,135.08 83.79,138.05 83.79,146.89 85.08,148.18 88.59,148.18 89.25,148.84 91.61,148.84 94.38,151.61 v1(94.38,153.16) ; v1(71.85,121.41) 71.85,120.02 71.34,119.51 71.34,117.6 70.83,117.09 70.83,114.55 75.41,109.98 76.42,109.98 77.69,108.71 77.69,104.9 79.6,103 79.6,87.76 85.11,82.25 85.11,74.6 82.14,71.63 80.36,71.63 78.71,69.98 v1(78.68,69.98)
D6: length 167
  TOP w0.127: v1(77.68,72.39) U22.35 ; CN7.8 98.93,132.84 v1(98.16,132.08) ; v1(71.34,120.27) 71.34,121.79 70.33,122.81 70.33,129.16 72.1,130.94 73.25,130.94 73.46,131.15 U7.60 75.11,131.15 75.53,131.57 v1(77.18,131.57) ; U5.H6 105.7,147.8 106.7,147.8 106.98,148.08 106.98,148.56 106.78,148.77 106.78,149.48 105.71,150.55 105.71,154.13 104.74,155.09 104.74,156.46 103.5,157.71 98.47,157.71 96.82,156.06 96.82,155.12 95.83,154.13 v1(95.65,154.13) 94.96,154.13 94.58,153.75 93.36,153.75 92.3,154.81 92.3,155.14 91.38,156.06 89.73,156.06 89.5,156.29 87.95,156.29 86.71,155.04 86.71,154.55 U2.F6
  BOTTOM w0.127: v1(98.16,132.08) 97.61,131.52 91.48,131.52 91.03,131.06 77.69,131.06 v1(77.18,131.57) 77.18,131.95 79.93,134.7 81.07,134.7 84.17,137.79 84.17,146.71 85.26,147.8 88.77,147.8 89.43,148.46 91.79,148.46 94.94,151.61 94.94,153.42 v1(95.65,154.13) ; v1(71.34,120.27) 71.22,120.27 70.96,120.02 70.96,117.86 70.45,117.35 70.45,114.3 75.15,109.6 76.17,109.6 77.31,108.46 77.31,104.65 77.82,104.14 77.82,95.25 79.22,93.85 79.22,84.63 82.52,81.33 82.52,76.58 79.72,73.79 79.08,73.79 v1(77.68,72.39)
D7: length 162
  TOP w0.102: U5.E6 102.45,148.42 102.84,148.81 102.84,150.95 102.66,151.13
  TOP w0.127: 102.66,151.13 102.43,151.36 102.43,153.62 103.78,154.97 103.78,156.31 103.14,156.95 99,156.95 97.58,155.52 97.58,154.76 95.98,153.16 v1(95.55,153.16) 95.55,152.96 95.24,152.65 93.24,152.65 91.54,154.36 91.54,154.79 91.03,155.3 89.81,155.3 89.3,155.8 88.16,155.8 87.47,155.12 87.47,154.56 U2.G6 ; v1(96.92,131.98) 96.77,131.98 95.9,132.84 CN7.7 ; v1(70.83,121.41) 70.83,121.67 69.82,122.68 69.82,129.29 73.18,132.65 U7.63 77.75,132.65 78.07,132.97 78.96,132.97 v1(79.22,132.72) ; U22.36 77.18,72.77 77.69,73.28 v1(77.69,73.41)
  BOTTOM w0.127: v1(95.55,153.16) 95.55,152.6 95.6,152.55 95.6,148.84 94.84,148.08 89.6,148.08 88.94,147.42 85.44,147.42 84.55,146.53 84.55,137.62 81.25,134.32 80.18,134.32 79.22,133.35 v1(79.22,132.72) 79.22,132.59 80.36,131.44 90.65,131.44 91.18,131.98 v1(96.92,131.98) ; v1(77.69,73.41) 78.45,74.17 79.47,74.17 82.14,76.83 82.14,81.13 78.84,84.43 78.84,93.62 77.44,95.02 77.44,103.89 76.93,104.39 76.93,107.19 70.07,114.05 70.07,117.6 70.58,118.11 70.58,120.27 70.83,120.52 v1(70.83,121.41)
D8: length 149.7
  TOP w0.102: U5.F3 103.88,145.49 v4(103.88,145.49)
  TOP w0.127: v1(76.68,72.39) U22.37 ; v1(70.07,121.54) 70.07,121.79 69.31,122.56 69.31,129.41 73.04,133.15 U7.64 77.62,133.15 77.82,133.35 79.22,133.35 v1(79.85,132.72) ; U2.B1 83.66,150.78 83.28,150.4 83.28,147.35 85.11,145.52 v1(85.11,145.41) ; v1(98.11,132.84) 98.11,133.02 99.21,134.11 CN7.6
  BOTTOM w0.127: v1(76.68,72.39) 76.7,72.39 77.18,72.87 77.18,73.61 80.41,76.83 80.41,82.25 78.45,84.2 78.45,93.37 77.06,94.77 77.06,103.63 76.55,104.14 76.55,106.93 68.93,114.55 68.93,117.09 70.2,118.36 70.2,120.52 70.45,120.78 70.45,120.9 70.07,121.28 v1(70.07,121.54) ; v1(98.11,132.84) 97.73,132.46 91.03,132.46 90.39,131.83 81.76,131.83 81.12,132.46 80.11,132.46 v1(79.85,132.72) 79.85,133.35 80.44,133.93 81.43,133.93 84.93,137.44 84.93,145.19 85.11,145.36 v1(85.11,145.41) 85.11,146.53 85.62,147.04 89.12,147.04 89.78,147.7 94.33,147.7 96.36,145.67 96.36,144.15 98.01,142.49 100.58,142.49 101.37,141.71 103.09,141.71 104.01,142.62 104.01,143.99 104.36,144.35 104.36,145.01 v4(103.88,145.49)
D9: length 147.6
  TOP w0.127: v1(96.87,132.92) 96.87,133.12 95.88,134.11 CN7.5 ; v1(85.57,146.33) 85.54,146.35 85.54,147.5 84.04,149 84.04,150.24 84.3,150.5 84.3,150.63 U2.C1 ; v4(104.96,144.59) 104.49,145.06 U5.G3 ; v1(80.49,132.97) 79.72,133.73 77.57,133.73 77.48,133.65 U7.65 72.91,133.65 68.47,129.21 68.47,122.76 69.56,121.67 69.56,121.16 v1(69.82,120.9) ; v1(76.68,73.33) 76.47,73.33 76.18,73.04 U22.38
  BOTTOM w0.127: v1(69.82,120.9) 69.82,118.62 68.55,117.35 68.55,114.3 76.17,106.68 76.17,99.82 75.28,98.93 75.28,95.12 77.95,92.46 77.95,84.07 80.03,81.99 80.03,77.04 76.68,73.69 v1(76.68,73.33) ; v1(96.87,132.92) 90.85,132.92 90.14,132.21 81.93,132.21 81.3,132.84 80.61,132.84 v1(80.49,132.97) 80.49,133.35 80.69,133.55 81.6,133.55 85.31,137.26 85.31,144.25 85.57,144.5 v1(85.57,146.33) 85.87,146.63 89.27,146.63 89.96,147.32 94.08,147.32 95.98,145.41 95.98,143.87 97.73,142.11 100.4,142.11 101.19,141.33 103.27,141.33 104.29,142.34 104.29,143.62 104.96,144.3 v4(104.96,144.59)
D10: length 150.9
  TOP w0.127: U2.C2 84.8,151.17 84.8,150.62 84.55,150.37 84.55,149.05 86.1,147.5 86.1,145.54 86.53,145.11 v1(86.53,144.91) ; CN7.4 99.08,135.38 97.86,134.16 v1(97.86,133.43) ; U5.F4 103.45,146.05 103.02,145.62 102.23,145.62 101.95,145.34 101.95,142.98 102.3,142.62 102.3,141.88 102.08,141.66 102.08,140.92 v4(102.03,140.87) ; v1(75.41,72.39) 75.18,72.16 U22.40 ; v1(68.93,121.54) 68.93,121.67 68.04,122.56 68.04,129.41 72.77,134.15 U7.66 76.89,134.15 76.93,134.11 80.36,134.11 81.25,133.22 81.76,133.22 v1(81.88,133.1)
  BOTTOM w0.127: v1(75.41,72.39) 76.04,73.03 76.04,73.71 79.65,77.32 79.65,81.81 77.57,83.9 77.57,92.13 75.91,93.78 75.91,93.85 74.9,94.87 74.9,99.19 75.79,100.08 75.79,106.43 68.17,114.05 68.17,117.6 69.44,118.87 69.44,120.65 69.31,120.78 69.31,121.16 v1(68.93,121.54) ; v1(97.86,133.43) 90.72,133.43 89.88,132.59 82.11,132.59 81.88,132.82 v1(81.88,133.1) 81.88,133.27 85.69,137.08 85.69,144.07 v1(86.53,144.91) 86.81,145.19 88.41,145.19 88.74,145.52 88.74,145.54 90.14,146.94 93.82,146.94 95.6,145.16 95.6,143.69 97.56,141.73 100.22,141.73 101.09,140.87 v4(102.03,140.87)
D11: length 144.5
  TOP w0.102: v4(104.88,145.58) 104.88,145.62 U5.G4
  TOP w0.127: v1(92.83,134.01) 92.81,134.04 92.81,135.08 93.11,135.38 CN7.3 ; v1(87.45,144.7) 87.45,144.75 86.48,145.72 86.48,147.68 85.19,148.97 85.19,149.73 85.57,150.11 85.57,150.96 85.19,151.34 U2.D2 ; v1(68.8,120.9) 68.42,121.28 68.42,121.54 67.66,122.3 67.66,129.67 72.64,134.65 U7.67 77.54,134.65 77.69,134.49 80.61,134.49 81.5,133.6 83.92,133.6 v1(84.04,133.48) ; v1(75.56,73.28) 74.68,72.4 U22.41
  BOTTOM w0.127: v1(75.56,73.28) 75.56,73.3 75.66,73.41 75.66,74.3 77.87,76.5 77.87,82.93 77.18,83.62 77.18,91.9 76.04,93.04 76.04,93.09 74.52,94.61 74.52,99.44 75.41,100.33 75.41,106.17 67.79,113.79 67.79,117.86 69.06,119.13 69.06,120.4 68.93,120.52 68.93,120.78 v1(68.8,120.9) ; v4(104.88,145.58) 105.4,145.06 105.4,144.36 104.67,143.62 104.67,142.11 102.97,140.41 100.98,140.41 100.04,141.35 97.38,141.35 95.22,143.51 95.22,144.91 93.57,146.56 90.34,146.56 88.49,144.7 v1(87.45,144.7) 86.07,143.33 86.07,136.91 84.04,134.87 v1(84.04,133.48) 84.3,133.22 89.88,133.22 90.6,133.93 92.75,133.93 v1(92.83,134.01)
D12: length 151
  TOP w0.102: 87.34,149.99 87.34,150.16 87.22,150.29 87.22,150.37 87.05,150.53 87.05,150.9 86.81,151.14 86.58,151.14 86.2,151.53 U2.E2 ; v4(103.89,146.62) U5.F5
  TOP w0.127: v1(92.6,137.29) 92.86,137.54 98.27,137.54 99.16,136.65 CN7.2 ; v1(68.04,121.03) 67.91,121.16 67.91,121.41 67.28,122.05 67.28,129.92 72.5,135.15 U7.68 77.67,135.15 77.95,134.87 80.87,134.87 81.5,134.24 85.06,134.24 v1(88.11,137.29) ; U22.43 73.68,72.14 74.06,72.52 74.14,72.52 74.64,73.03 74.64,73.1 v1(74.8,73.25) ; v1(90.09,144.15) 89.91,144.32 89.91,147.17 87.34,149.73 87.34,149.99
  BOTTOM w0.127: v4(103.89,146.62) 103.89,146.62 104.45,146.05 105.01,146.05 105.71,145.35 105.71,144.16 105.05,143.5 105.05,141.94 103.14,140.03 100.81,140.03 99.87,140.97 97.12,140.97 94.84,143.26 94.84,144.65 93.31,146.18 90.57,146.18 90.09,145.69 v1(90.09,144.15) 90.01,144.15 86.46,140.59 86.46,138.43 87.6,137.29 v1(88.11,137.29) v1(92.6,137.29) ; v1(68.04,121.03) 68.04,120.78 68.68,120.14 68.68,119.38 67.41,118.11 67.41,113.54 75.03,105.92 75.03,101.09 72.74,98.81 72.74,94.49 76.8,90.42 76.8,83.36 77.49,82.68 77.49,76.76 75.28,74.55 75.28,73.79 74.8,73.3 v1(74.8,73.25)
D13: length 163.1
  TOP w0.127: U5.G6 104.45,148.07 104.84,148.46 105.94,148.46 v4(105.96,148.49) ; v1(90.75,145.72) 90.77,145.75 90.77,147.52 88.23,150.06 88.23,150.24 87.8,150.67 87.8,150.98 87.6,151.18 87.23,151.18 86.88,151.53 U2.F2 ; v1(85.06,88.52) 85.08,88.49 85.08,87.55 84.4,86.87 84.4,85.9 83.36,84.86 71.27,84.86 68.9,82.5 62.81,82.5 60.96,80.64 ; U22.44 73.18,72.33 72.87,72.64 v1(72.87,72.77)
  BOTTOM w0.127: 60.96,80.64 60.96,80.64 62.07,79.53 62.07,78.21 68.52,71.75 71.85,71.75 v1(72.87,72.77) ; v1(85.06,88.52) 85.57,88.01 86.33,88.01 86.71,88.39 94.08,88.39 94.96,89.28 98.65,89.28 102.71,93.34 102.71,98.3 104.49,100.08 104.49,108.33 104.11,108.71 104.11,136.91 105.81,138.61 106.5,138.61 107.72,139.83 107.72,141.86 108.43,142.57 108.43,147.65 107.16,148.92 106.39,148.92 v4(105.96,148.49) 105.96,144.02 105.43,143.48 105.43,141.76 103.24,139.57 100.68,139.57 99.66,140.59 96.87,140.59 94.46,143 94.46,144.4 93.06,145.8 90.9,145.8 90.82,145.72 v1(90.75,145.72)
D14: length 156.9
  TOP w0.127: v1(85.06,89.66) 85.57,89.15 85.57,87.48 84.78,86.69 84.78,85.5 83.74,84.45 71.49,84.45 69.13,82.09 64.95,82.09 63.5,80.64 ; U2.F1 86.69,150.51 86.96,150.24 86.96,149.38 89.53,146.81 89.53,143.81 90.62,142.72 93.47,142.72 v1(93.95,142.24) ; v1(71.6,72.77) 71.6,72.64 72.18,72.06 U22.46 ; U5.F6 104.05,147.46 106.61,147.46 106.88,147.19 v1(106.9,147.19)
  BOTTOM w0.127: v1(93.95,142.24) 93.95,142.11 96.23,139.83 99.23,139.83 100.25,138.81 103.6,138.81 106.19,141.4 106.19,142.52 106.9,143.23 106.9,144.42 106.55,144.78 106.55,146.84 v1(106.9,147.19) 106.9,147.2 106.91,147.21 107.4,147.21 107.66,146.94 107.66,142.93 106.95,142.21 106.95,140.18 106.14,139.37 105.3,139.37 103.35,137.41 103.35,108.2 103.73,107.82 103.73,100.58 101.82,98.68 101.82,95.63 98.9,92.71 98.9,90.93 98.01,90.04 94.46,90.04 93.57,89.15 85.57,89.15 v1(85.06,89.66) ; 63.5,80.64 63.5,79.72 64.87,78.36 64.87,77.47 70.07,72.26 71.09,72.26 v1(71.6,72.77)
D15: length 151
  TOP w0.127: v1(86.07,88.52) 86.07,87.43 85.16,86.51 85.16,85.17 84.07,84.07 71.75,84.07 69.39,81.71 66.69,81.71 66.04,81.06 66.04,80.64 ; U2.G1 87.44,150.4 87.85,149.99 87.85,149.86 89.76,147.96 89.76,147.88 90.29,147.35 90.29,144.88 90.8,144.37 90.8,143.46 91.15,143.1 93.82,143.1 v1(93.95,142.98) ; U22.47 71.68,71.92 70.83,72.77 v1(70.71,72.77) ; v4(106.57,148.39) 106.45,148.51 106.45,149.35 106.22,149.58 104.97,149.58 U5.G7
  BOTTOM w0.102: 106.9,148.39 v4(106.57,148.39)
  BOTTOM w0.127: v1(70.71,72.77) 70.45,72.77 67.41,75.82 67.41,78.36 66.04,79.72 66.04,80.64 ; v1(93.95,142.98) 93.95,142.88 96.62,140.21 99.41,140.21 100.43,139.19 103.42,139.19 105.81,141.58 105.81,143.48 106.27,143.94 106.27,148.08 v4(106.57,148.39) ; v1(86.07,88.52) 86.33,88.77 93.82,88.77 94.71,89.66 98.27,89.66 99.28,90.68 99.28,92.46 102.2,95.38 102.2,98.42 104.11,100.33 104.11,108.08 103.73,108.46 103.73,137.16 105.56,138.99 106.32,138.99 107.33,140 107.33,142.04 108.05,142.75 108.05,147.37 107.03,148.39 106.9,148.39
E5V: length 49.4
  TOP w0.508: L2.3 4.48,37.83 ; L2.3 4.48,35.49 ; L2.3 5.65,36.66 ; L2.3 3.32,36.66 ; 17.24,37.29 C100.1 ; C100.1 17.24,40.69 ; C100.1 14.52,38.99 ; JP17.8 4.79,64.64 4.79,67.18 7.97,70.36 9.49,70.36 10.18,71.04 D5.1
  BOTTOM w0.508: L2.3 3.52,37.62 JP17.8
I2C_SCL: length 330.9
  TOP w0.127: v1(119.35,145.41) 118.71,144.78 CN3.3 ; v1(83.64,34.59) 83.46,34.59 82.23,33.37 U29.H1 ; U32.4 88.88,21.58 88.36,22.1 86.9,22.1 v1(86.39,22.61) ; v1(42.25,110.31) 42.32,110.31 42.77,110.76 42.77,111.23 42.26,111.73 42.26,118.62 39.21,121.67 39.21,127.25 39.85,127.89 44.29,127.89 R60.1 R61.1 ; U33.19 v1(79.68,21.93) ; v1(118.59,70.1) 84.14,70.1 82.87,68.83 55.09,68.83 54.32,68.07 45.18,68.07 44.19,67.08 v1(44.16,67.08)
  BOTTOM w0.127: v1(79.68,21.93) 79.82,21.78 85.53,21.78 86.35,22.61 v1(86.39,22.61) 86.39,23.43 86.38,23.44 86.38,32.72 84.7,34.39 83.84,34.39 v1(83.64,34.59) 83.64,34.8 84.14,35.31 84.14,36.53 83.37,37.3 78.04,37.3 75.21,40.13 70.35,40.13 67.1,36.88 53.56,36.88 44.32,46.13 44.32,66.93 v1(44.16,67.08) 43.94,67.31 41.88,67.31 36.93,72.26 36.93,93.98 36.72,94.18 36.72,105.56 41.47,110.31 v1(42.25,110.31) ; v1(119.35,145.41) 119.53,145.24 119.53,129.84 115.28,125.6 115.28,95.2 119.25,91.24 119.25,70.76 v1(118.59,70.1)
I2C_SDA: length 337.3
  TOP w0.127: v1(85.42,22.62) 87.61,20.44 U32.5 ; CN3.1 121.25,144.02 120.36,144.91 v1(120.36,145.41) ; v1(119.22,70.1) 118.71,69.6 118.46,69.6 118.33,69.72 84.3,69.72 83.15,68.58 55.21,68.58 54.45,67.82 45.56,67.82 44.16,66.42 43.53,66.42 v1(43.28,66.67) ; U29.F3 v2(81.48,32.24) ; R58.1 R57.1 44.16,128.14 39.59,128.14 38.96,127.51 38.96,121.54 42.01,118.49 42.01,111.21 v1(42.26,110.95) ; v1(78.45,21.72) 78.84,21.34 78.84,20.7 79.23,20.31 U33.20
  BOTTOM w0.127: v1(119.22,70.1) 119.5,70.38 119.5,91.57 115.54,95.53 115.54,125.35 119.93,129.74 119.93,144.98 v1(120.36,145.41) ; v1(42.26,110.95) 41.7,110.95 36.42,105.67 36.42,93.92 36.67,93.67 36.67,72.01 41.88,66.8 43.15,66.8 v1(43.28,66.67) 43.61,66.34 43.61,46.46 53.56,36.5 67.28,36.5 70.53,39.75 75.16,39.75 77.94,36.96 82.73,36.96 83.09,36.6 83.09,35.86 81.12,33.88 81.12,32.6 81.48,32.24 v2(81.48,32.24) 81.54,32.24 83.31,34.01 84.45,34.01 85.69,32.77 85.69,22.9 v1(85.42,22.62) 84.99,22.19 80.81,22.19 80.43,22.58 79.32,22.58 v1(78.45,21.72)
IRDA_RX: length 21.8
  TOP w0.127: v1(3.4,96.39) 3.49,96.49 U11.4
  BOTTOM w0.127: v1(3.4,96.39) 3.27,96.27 3.27,90.93 10.89,83.31 13.43,83.31 JP15.4
LCD_CSN: length 47.8
  TOP w0.127: v1(56.48,66.65) 56.89,67.06 89.38,67.06 93.81,62.62 CN19.1
  BOTTOM w0.127: SB46.2 SB47.2 57.37,65.76 v1(56.48,66.65)
LCD_D0: length 23.3
  TOP w0.127: U22.23 82.18,62.94 82.51,62.61 90.14,62.61 96.74,56.01 99.73,56.01 CN19.6
LCD_D1: length 21
  TOP w0.127: U22.22 81.68,62.94 82.39,62.23 89.63,62.23 96.87,54.99 98.72,54.99 CN19.7
LCD_D2: length 25.5
  TOP w0.127: CN19.8 100.24,53.98 97.12,53.98 89.25,61.85 82.39,61.85 81.63,62.61 80.87,62.61 80.68,62.8 U22.20
LCD_D3: length 23.6
  TOP w0.127: U22.19 80.18,62.92 80.74,62.36 81.38,62.36 82.26,61.47 88.49,61.47 97.5,52.46 CN19.9
LCD_D4: length 28.1
  TOP w0.127: U22.17 79.18,62.9 79.98,62.1 81.12,62.1 82.14,61.09 88.23,61.09 97.94,51.38 100.18,51.38 CN19.10
LCD_D5: length 26.3
  TOP w0.127: U22.16 78.68,62.64 79.47,61.85 80.99,61.85 82.14,60.71 87.94,60.71 CN19.11
LCD_D6: length 30.5
  TOP w0.127: U22.14 77.68,62.88 79.09,61.47 80.87,61.47 81.88,60.45 86.96,60.45 98.41,49.01 100.36,49.01 CN19.12
LCD_D7: length 28.7
  TOP w0.127: U22.13 77.18,62.87 78.84,61.21 80.61,61.21 81.76,60.07 86.03,60.07 CN19.13
LCD_D8: length 32.7
  TOP w0.127: CN19.14 100.17,46.28 98.52,46.28 85.11,59.69 81.63,59.69 80.36,60.96 78.58,60.96 76.68,62.86 U22.12
LCD_D9: length 31
  TOP w0.127: U22.11 76.18,62.6 78.07,60.71 79.98,60.71 81.38,59.31 84.25,59.31 CN19.15
LCD_D10: length 35.2
  TOP w0.127: U22.9 75.18,62.84 77.69,60.33 79.85,60.33 81.12,59.05 83.13,59.05 98.39,43.79 100.22,43.79 CN19.16
LCD_D11: length 33.7
  TOP w0.127: U22.8 74.68,62.83 77.57,59.94 79.85,59.94 81.12,58.67 82.9,58.67 98.72,42.85 CN19.17
LCD_D12: length 41.3
  TOP w0.127: CN19.18 100.19,41.22 98.19,41.22 97.38,42.04 97.38,43.69 82.9,58.17 81.25,58.17 79.85,59.56 73.88,59.56 72.74,60.71 72.74,61.8 73.68,62.74 U22.6
LCD_D13: length 39.4
  TOP w0.127: U22.5 73.18,62.8 72.49,62.1 72.49,60.45 73.76,59.18 79.72,59.18 81.12,57.78 82.65,57.78 97,43.43 97,41.91 98.7,40.2 98.7,39.78 CN19.19
LCD_D14: length 43.5
  TOP w0.127: CN19.20 100.18,39.76 99.14,38.72 98.41,38.72 97.63,39.5 97.63,40.64 96.55,41.72 96.55,43.37 82.65,57.28 81.15,57.28 79.62,58.8 73.63,58.8 72.18,60.25 U22.3
LCD_D15: length 42.1
  TOP w0.127: U22.2 71.68,60.11 73.37,58.42 79.52,58.42 81.05,56.9 82.54,56.9 96.04,43.4 96.04,41.72 97.33,40.44 97.33,39.32 98.72,37.92 CN19.21
LCD_NE3_BUF: length 33.9
  TOP w0.127: R161.2 82.68,73.19 U22.25 82.68,70.27 81.83,69.42 74.06,69.42 73.25,70.23 71.47,70.23 71.18,70.52 U22.48 71.18,71.76 70.86,72.09 66.52,72.09 65.98,72.62 59.2,72.62 v1(58.97,72.39)
  BOTTOM w0.127: SB49.2 SB48.2 57.12,71.58 57.93,72.39 v1(58.97,72.39)
LCD_RDN: length 50.9
  TOP w0.127: U21.6 55.39,64.36 57.58,66.55 88.74,66.55 96.11,59.18 100.37,59.18 CN19.4
LCD_RS: length 51.9
  TOP w0.127: CN19.2 99.88,64.01 93.06,64.01 89.76,67.31 56.05,67.31 54.78,66.04 v1(54.45,66.04)
  BOTTOM w0.127: v1(54.45,66.04) 54.45,65.02 SB45.2 SB44.2
LCD_RSTN: length 47.7
  TOP w0.127: U21.8 56.39,64.68 58.01,66.29 88.36,66.29 97.12,57.54 CN19.5
LCD_WRN: length 48.4
  TOP w0.127: U21.5 54.89,64.4 57.3,66.8 89,66.8 95.73,60.07 98.72,60.07 CN19.3
LCDCOM0: length 57.5
  TOP w0.127: U7.100 58.75,132.53 56.86,130.64 56.86,125.26 v1(57.59,124.54)
  BOTTOM w0.127: v1(57.59,124.54) 57.59,124.14 55.85,122.4 55.85,119.89 48.58,112.62 44.42,112.62 43.33,111.54 41.84,111.54 34.71,104.41 34.71,96.74 CN11.3
LCDCOM1: length 59.5
  TOP w0.127: U7.101 58.25,132.41 56.61,130.77 56.61,124.67 v1(56.83,124.45)
  BOTTOM w0.127: v1(56.83,124.45) 56.58,124.45 56.12,123.99 56.12,123.83 51.15,118.86 48.05,118.86 48.05,118.86 47.64,118.86 47.33,118.54 47.33,117.53 45.62,115.82 43.36,115.82 41.27,115.82 32.56,107.11 32.56,99.36 32,98.8 32,96.91 CN11.1
LCDCOM2: length 75.8
  TOP w0.127: U7.102 57.75,140.21 57.5,140.46 56.99,140.46 55.98,141.48 55.98,146.43 55.09,147.32 47.21,147.32 46.07,146.18 46.07,136.27 38.32,128.52 38.32,121.28 41.5,118.11 41.5,108.33 v1(42.13,107.7)
  BOTTOM w0.127: CN11.5 38.96,96.74 38.96,104.52 v1(42.13,107.7)
LCDCOM3: length 34.5
  TOP w0.127: U7.140 50.24,121.65 49.75,121.16 45.82,121.16 44.93,120.27 44.93,107.42 v1(44.04,106.53)
  BOTTOM w0.127: v1(44.04,106.53) 44.04,106.5 41.55,104.01 41.55,97.28 40.64,96.37 CN11.7
LCDCOM4: length 83
  TOP w0.127: v1(56.57,123.81) 55.7,124.68 55.7,130.71 56.92,131.94 56.92,134.56 55.34,136.15 U7.111 ; v1(36.04,76.68) 36.14,76.58 39.12,76.58 CN14.7
  BOTTOM w0.127: v1(56.57,123.81) 47.19,114.43 41.17,114.43 33.9,107.16 33.9,93.32 35.15,92.08 35.15,83.06 36.42,81.79 36.42,77.06 v1(36.04,76.68)
LCDCOM5: length 86.5
  TOP w0.127: U7.112 55.02,135.65 56.54,134.12 56.54,131.94 55.21,130.61 55.21,126.53 v1(55.25,126.49) ; v1(30.98,78.05) 30.98,77.29 31.82,76.45 34.82,76.45 35.53,77.17 36.11,77.17 37.05,78.11 CN14.5
  BOTTOM w0.127: v1(55.25,126.49) 54.01,126.49 51.39,123.88 51.39,123.26 51.13,123 49.92,123 49.6,122.68 46.56,122.68 43,119.13 40.46,119.13 29.53,108.2 29.53,100.28 29.32,100.08 29.31,100.08 28.92,99.69 28.92,93.07 30.78,91.21 30.78,78.38 30.98,78.18 v1(30.98,78.05)
LCDCOM6: length 81.1
  TOP w0.127: CN14.3 34.54,77.09 32.1,77.09 31.79,77.39 31.79,78.28 v1(31.46,78.61) ; v1(55.01,125.84) 54.58,126.27 54.58,130.88 55.91,132.21 55.91,133.76 54.53,135.15 U7.113
  BOTTOM w0.127: v1(31.46,78.61) 31.41,78.66 31.41,91.49 29.58,93.33 29.58,99.43 30.17,100.02 30.17,107.93 40.72,118.49 43.26,118.49 46.61,121.84 49.79,121.84 50.11,122.16 51.19,122.16 52.03,123 52.03,123.61 54.27,125.86 54.99,125.86 v1(55.01,125.84)
LCDCOM7: length 72.3
  TOP w0.127: U7.116 53.39,133.65 53.94,133.1 53.94,132.78 54.57,132.16 54.57,131.76 54.32,131.51 53.94,131.14 53.94,125.7 54.49,125.14 v1(54.49,125.09)
  BOTTOM w0.127: CN14.1 32.07,79.05 32.07,91.74 30.47,93.34 30.47,99.43 30.95,99.91 30.95,107.72 40.42,117.2 40.42,117.29 40.99,117.86 43.53,117.86 43.9,118.23 46.74,121.07 49.91,121.07 50.37,121.53 51.61,121.53 54.37,124.28 54.37,124.97 v1(54.49,125.09)
LCDSEG0: length 44.6
  TOP w0.508: v1(85.44,114.43) 85.31,114.3 82.39,114.3
  BOTTOM w0.508: v1(85.44,114.43) 85.44,113.28 84.55,112.39 84.55,102.62 83.15,101.22 83.15,99.44 82.77,99.06 82.77,91.44 82.9,91.31 82.9,87.63 86.2,84.33 87.09,84.33 90.27,81.15 90.27,79.28 CN14.47
LCDSEG1: length 26.3
  TOP w0.127: CN11.35 77.07,96.76 80.34,96.76 81.12,97.54 81.88,97.54 82.26,97.92 82.26,99.44 v1(82.01,99.69) ; 82.39,115.7 83.03,115.7 v1(83.41,115.32)
  BOTTOM w0.127: v1(83.41,115.32) 83.41,103.38 81.88,101.85 81.88,99.82 v1(82.01,99.69)
LCDSEG2: length 30.8
  TOP w0.508: v1(84.68,115.32) 84.68,115.95 83.53,117.09 82.39,117.09 ; CN11.33 75.11,97.33 79.78,97.33 80.11,97.66 80.11,99.19 81.25,100.33 v1(82.39,100.33)
  BOTTOM w0.508: v1(82.39,100.33) 82.39,101.73 83.92,103.25 83.92,112.9 84.68,113.67 v1(84.68,115.32)

# Allegro board MB1144.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NETCN12_14: length 18.2
  TOP w0.127: R162.1 113.71,72.9 112.67,71.86 110.33,71.86 110,71.53 v1(110,71.45) ; CN12.14 v1(109.32,79.88) R154.1 ; v1(109.82,77.22) 110.19,76.85 U19.5
  BOTTOM w0.127: v1(109.32,79.88) 109.82,79.38 v1(109.82,77.22) 109.82,71.63 v1(110,71.45)
NETCN12_16: length 26.9
  TOP w0.127: CN12.16 v1(109.32,78.61) 110.33,78.61 R156.1 111.87,77.07 U19.4 ; v1(107.82,90.32) 107.92,90.42 110.56,90.42 111.19,91.06 112.82,91.06 113.96,89.92 113.96,89.59 R131.1
  BOTTOM w0.127: v1(109.32,78.61) 109.32,79.12 107.26,81.18 107.26,89.76 v1(107.82,90.32)
NETCN12_18: length 116.3
  TOP w0.127: 107.41,77.34 108.55,77.34 109.95,75.95 111.47,75.95 111.87,75.55 U19.3 111.87,73.8 111.35,73.28 88.74,73.28 86.71,75.31 60.37,75.31 59.58,74.52 55.54,74.52 55.19,74.17 52.52,74.17 52.01,73.66 49.57,73.66 49.5,73.58 v1(49.47,73.58)
  BOTTOM w0.127: 57.15,111.99 57.15,111.41 55.85,110.11 51.4,110.11 49.24,107.95 49.24,102.49 49.9,101.83 49.9,93.47 49.37,92.94 49.37,84.71 49.93,84.15 49.93,76.05 49.52,75.64 49.52,73.63 v1(49.47,73.58)
NETCN12_20: length 112.5
  TOP w0.127: v1(48.81,73.58) 49.4,74.17 50.16,74.17 50.41,73.91 51.89,73.91 52.39,74.42 55.06,74.42 55.42,74.78 59.46,74.78 60.24,75.56 87.12,75.56 89.07,73.61 110.03,73.61 110.57,74.15 U19.1 110.57,75.45 110.33,75.69 109.44,75.69 109.06,76.07 CN12.20
  BOTTOM w0.127: v1(48.81,73.58) 49.07,73.84 49.07,75.82 49.68,76.43 49.68,84.02 49.12,84.58 49.12,93.07 49.65,93.6 49.65,101.7 48.86,102.49 48.86,108.33 51.02,110.49 54.71,110.49 55.21,111 SB39.2
NETCN13_1: length 13.3
  BOTTOM w0.508: CN13.1 3.91,78.11 6.78,78.11 7.11,77.77 12.97,77.77 JP15.6
NETCN13_2: length 211.7
  TOP w0.279: U12.7 19.52,94.75 19.4,94.87
  TOP w0.381: U10.13 v1(107.58,107.97)
  TOP w0.508: 19.4,94.87 16.3,94.87 12.87,98.3 6.06,98.3 5.2,97.44 U11.3 3.09,97.44 2.41,96.75 2.41,90.35 1.29,89.23 1.29,76.45 2.31,75.44 3.78,75.44 CN13.2 ; v1(22.45,51.31) 28.06,56.92 37.51,56.92 40.33,59.74 v1(68.83,59.74)
  BOTTOM w0.508: CN13.2 10.46,76.96 11.45,75.97 11.45,68.91 12.92,67.44 12.92,64.52 22.45,54.99 v1(22.45,51.31) ; v1(68.83,59.74) 79.98,59.74 92.6,72.36 101.26,72.36 103.68,74.78 103.68,87.58 105.35,89.26 105.35,96.24 107.11,97.99 107.11,104.06 106.83,104.34 106.83,107.21 v1(107.58,107.97)
NETCN14_2: length 40.6
  TOP w0.127: CN18.3 17.61,51.32 R178.2 18.26,51.94 19.78,51.94 20.03,52.2 20.03,52.32 27.02,59.31 27.02,77.6 30.07,80.64 33.02,80.64
NETCN14_4: length 2.4
  TOP w0.127: R140.2 35.56,81.82 35.56,80.64
NETCN14_6: length 2.7
  TOP w0.127: R141.2 37.31,81.44 38.1,80.64
NETCN14_8: length 3.1
  TOP w0.127: R142.2 40.64,81.38 40.64,80.64
NETCN14_10: length 46.2
  TOP w0.381: R158.1 13.61,77.77 17.11,77.77 18.71,79.38 26.44,79.38 33.34,86.28 38.65,86.28 40.1,84.84 40.1,83.69 43.15,80.64 43.18,80.64
  TOP w0.508: R158.1 12.16,76.58 JP15.5 JP15.3 JP15.1
NETCN14_12: length 2.9
  TOP w0.127: R143.2 45.72,81.82 45.72,80.64
NETCN14_14: length 2.9
  TOP w0.127: R144.2 48.26,81.82 48.26,80.64
NETCN14_16: length 2.9
  TOP w0.127: 50.8,80.64 52.04,81.88 R145.2
NETCN14_18: length 2.8
  TOP w0.127: R146.2 53.34,82.07 53.34,80.64
NETCN14_20: length 2.9
  TOP w0.127: R147.2 55.88,81.82 55.88,80.64
NETCN14_22: length 2.9
  TOP w0.127: 58.42,80.64 58.42,81.82 R148.2
NETCN14_32: length 3
  TOP w0.127: 71.12,80.64 71.12,81.57 R151.2
NETCN14_40: length 94.6
  TOP w0.127: v1(91.1,141.5) 90.11,141.5 88,143.61 85.67,143.61 82.9,146.38 82.9,150.74 U2.A1 ; 81.28,80.64 82.04,80.64 82.92,81.53 85.34,81.53 87.45,83.64 87.45,85.24 88.49,86.28 88.49,90.42 87.98,90.93 v1(87.98,91.19)
  BOTTOM w0.127: v1(87.98,91.19) 88.23,91.19 89.38,92.33 93.82,92.33 98.14,96.65 98.14,99.44 100.11,101.41 100.11,109.41 100.68,109.98 100.68,135.03 98.16,137.54 94.66,137.54 91.1,141.1 v1(91.1,141.5)
NETCN14_42: length 92.7
  TOP w0.127: U2.B2 84.04,151.18 84.04,150.62 83.66,150.24 83.66,147.6 85.72,145.54 85.72,145.36 85.79,145.29 85.79,144.93 86.58,144.15 88.08,144.15 90.27,141.96 91.61,141.96 91.94,141.63 v1(92.04,141.63) ; v1(89.76,90.81) 89.5,90.81 89,90.3 89,86.31 87.83,85.14 87.83,83.52 84.96,80.64 83.82,80.64
  BOTTOM w0.127: v1(92.04,141.63) 92.04,141.35 95.09,138.3 98.52,138.3 101.44,135.38 101.44,109.63 100.88,109.07 100.88,100.91 99.03,99.06 99.03,96.14 94.46,91.57 92.93,91.57 92.17,90.81 v1(89.76,90.81)
NETCN14_44: length 3.3
  TOP w0.127: 86.36,80.64 86.36,80.8 R149.2
NETCN14_46: length 3.5
  TOP w0.127: R150.2 90.9,82.14 89.41,80.64 88.9,80.64
NETCN15_3: length 30.4
  TOP w0.127: v1(109.87,85.8) 110.19,86.12 RS1.6 ; v1(112.26,84.33) 112.26,84.1 111.87,83.71 U18.1 111.87,82.92 112.74,82.04 112.74,81.05 113.66,80.14 121.25,80.14 122.02,80.9 122.02,84.99 CN15.3 118.71,86.36 R131.2 R126.1
  BOTTOM w0.127: v1(112.26,84.33) 112.26,84.71 111.17,85.8 v1(109.87,85.8)
NETCN15_11: length 5.9
  TOP w0.127: CN15.11 R159.2 116.3,77.6 R157.1
NETCN15_17: length 4
  TOP w0.127: R163.2 CN15.17
NETCN15_19: length 4.1
  TOP w0.127: CN15.19 120.4,66.29 R164.2
NETCN17_2: length 6.3
  TOP w0.155: CN17.2 115.46,50.98 115.76,51.28 115.76,51.96 115.61,52.11 114.34,52.11 113.81,51.58 113.81,50.98 113.19,50.36 112.68,50.36 R180.2
NETCN17_3: length 8
  TOP w0.155: R177.2 R179.2 112.68,50.74 113.03,50.74 113.43,51.14 113.43,51.74 114.18,52.49 115.76,52.49 116.14,52.12 116.14,51.23 116.4,50.98 CN17.3
NETCN18_1: length 48.4
  TOP w0.127: CN18.1 17.54,53.52 R175.2 18.7,54.67 21.29,54.67 26.38,59.77 26.38,78.46 33.65,85.72 37.81,85.72 R142.1
NETCN18_2: length 47
  TOP w0.127: CN18.2 17.59,52.42 R176.2 18.26,53.09 20.34,53.09 26.77,59.51 26.77,78.36 33.78,85.37 36.52,85.37 R141.1
NETCN18_5: length 49.7
  TOP w0.127: CN18.5 16.26,49.12 16.99,48.39 20.16,48.39 20.42,48.64 20.42,51.56 27.78,58.93 27.78,77.19 30.09,79.5 33.5,79.5 34.13,80.14 34.13,83.19 R140.1
NETCN18_7: length 70.9
  TOP w0.127: CN18.7 17.42,46.92 R182.2 18.13,47.62 20.54,47.62 21.3,48.39 21.3,51.31 28.8,58.8 28.8,70.87 32.86,74.93 33.86,74.93 34.37,75.44 43.78,75.44 44.29,75.95 49.5,75.95 50.26,76.71 53.92,76.71 54.34,77.13 56.39,77.13 57.12,77.85 57.12,81.92 58.01,82.8 58.01,83.69 R147.1
NETCN18_8: length 71.9
  TOP w0.127: R148.1 58.52,83.44 58.52,82.68 57.5,81.66 57.5,77.85 56.51,76.86 54.45,76.86 54.04,76.45 50.39,76.45 49.63,75.69 44.42,75.69 43.91,75.18 34.64,75.18 34,74.55 32.99,74.55 29.05,70.61 29.05,58.67 21.56,51.18 21.56,48.01 20.16,46.61 18.26,46.61 R185.2 17.46,45.82 CN18.8
NETCN18_10: length 2.9
  TOP w0.127: CN18.10 7.08,41.81 R194.2
NETCN19_23: length 10.1
  TOP w0.127: R259.2 93.82,38.23 v1(92.93,38.23) 92.42,38.23 92.04,38.61 T6.3
  BOTTOM w0.127: CN19.23 96.48,34.68 v1(92.93,38.23)
NETCN19_31: length 12.5
  TOP w0.127: CN19.31 99.66,23.58 99.66,21.34 98.76,20.44 U32.16
NETCN19_32: length 16.2
  TOP w0.127: CN19.32 102.46,23.33 102.46,20.95 100.44,18.93 U32.13
NETCN19_33: length 8.7
  TOP w0.127: CN19.33 97.92,21.17 U32.1
NETCN19_34: length 11
  TOP w0.127: U32.15 91.79,19.93 91.92,20.07 99.35,20.07 CN19.34
NETCN20_2: length 3.5
  TOP w0.203: R192.2 124.43,42.42 125.95,40.9 CN20.2
NETCN20_3: length 4
  TOP w0.203: R191.1 121.13,41.4 122.02,41.4 123.05,40.37 CN20.3
NETCN21_2: length 3.5
  TOP w0.203: CN21.2 125.95,27.06 124.3,28.7 R221.1
NETCN21_3: length 4
  TOP w0.203: R220.1 121.13,27.69 121.89,27.69 123.05,26.53 CN21.3
NETCN21_4: length 44.4
  TOP w0.203: CN21.4 121.18,18.29 107.16,18.29 105.12,20.32 105.12,23.88 103.35,25.65 98.14,25.65 97.12,24.64 84.42,24.64 83.28,25.78 R227.1
NETCN21_6: length 25.7
  TOP w0.203: R225.2 90.39,25.27 96.74,25.27 97.63,26.16 113.66,26.16 CN21.6
NETCN22_1: length 10.5
  TOP w0.508: 10.64,19.3 CN22.1 ; CN22.1 11.83,21.59 ; CN22.1 9.44,21.59 ; CN22.1 10.64,23.88 ; 16.34,22.13 U31.1 ; U31.1 17.62,21.65 ; U31.1 18.9,22.13 ; U31.1 17.62,22.61
NETCN23_2: length 3.4
  TOP w0.127: v1(69.69,27.36) U30.16
  BOTTOM w0.127: v1(69.69,27.36) 69.95,27.36 71.09,28.5 CN23.2
NETCN23_3: length 5.7
  TOP w0.127: v1(69.69,26.34) 70.96,27.61 U30.15
  BOTTOM w0.127: CN23.3 68.55,27.48 v1(69.69,26.34)
NETCN23_4: length 10.9
  TOP w0.127: v1(66.77,22.86) 69.69,19.94 U30.13
  BOTTOM w0.127: CN23.4 66.01,23.62 v1(66.77,22.86)
NETCN23_7: length 25.7
  TOP w0.127: v1(62.93,4.22) 62.93,10.64 64.36,12.06 66.39,12.06 68.04,13.72 68.04,17.14 67.15,18.03 U30.11
  BOTTOM w0.127: CN23.7 68.55,3.94 67.05,2.44 64.71,2.44 v1(62.93,4.22)
NETCN23_8: length 20.5
  TOP w0.127: 68.42,19.21 68.42,13.21 66.77,11.56 64.84,11.56 63.7,10.41 v1(63.7,4.32)
  BOTTOM w0.127: CN23.8 66.01,3.95 66,3.94 64.08,3.94 v1(63.7,4.32)
NETCN23_18: length 13.5
  TOP w0.127: v1(58.39,23.62) 59.79,22.23 63.72,22.23 64.61,21.34 U30.9 64.61,17.78 R242.2
  BOTTOM w0.127: v1(58.39,23.62) CN23.18
NETD3_1: length 2.2
  TOP w0.127: D3.1 41.62,126.22 R59.1
NETD3_2: length 2.8
  TOP w0.127: D3.2 40.12,123.17 JP8.2
NETD4_1: length 2.2
  TOP w0.127: D4.1 JP9.2
NETD4_2: length 9.5
  TOP w0.127: U10.16 v1(106.6,107.97) ; R93.1 106.65,112.09 106.6,112.14 v1(106.6,112.17) 106.57,112.17 105.71,113.03 D4.2
  BOTTOM w0.127: v1(106.6,107.97) 106.78,108.14 106.78,111.99 v1(106.6,112.17)
NETJP4_2: length 13.3
  TOP w0.127: U8.8 16.73,128.02 15.84,128.91 15.84,133.1 17.11,134.37 R45.1 17.49,137.54 JP4.2
NETJP4_3: length 2.9
  TOP w0.127: R46.1 20.03,138.68 JP4.3
NETJP5_1: length 144.2
  TOP w0.508: JP5.1 108.43,132.84 109.44,132.84 110.84,131.44 110.84,127.51 v1(111.42,126.92)
  BOTTOM w0.508: v1(111.42,126.92) 111.42,123.75 110.79,123.11 110.79,115.14 110.46,114.81 110.46,108.97 111.12,108.31 111.12,100.71 110.79,100.38 110.79,94.28 110.03,93.52 110.03,91.49 111.78,89.74 116.3,89.74 118.28,87.76 118.28,72.16 117.01,70.89 117.01,69.85 116.78,69.62 116.78,61.01 112.9,57.12 112.9,47.29 104.87,39.27 RV3.2
NETJP5_2: length 4.4
  BOTTOM w0.508: JP5.2 JP7.2
NETJP5_3: length 8.9
  TOP w0.508: JP5.3 R52.2 R51.1
NETJP6_1: length 3.2
  TOP w0.127: R55.2 JP6.1
NETJP7_1: length 2.4
  TOP w0.508: R63.1 JP7.1
NETJP10_2: length 6
  TOP w0.508: L1.1 94.96,104.65 JP10.2
NETJP11_4: length 63.5
  TOP w0.127: T2.1 T2.6 57.31,89.86 R123.1 ; R123.1 57.63,90.81 T2.5 T2.2 ; R123.1 55.21,90.17 54.34,89.3 U15.12 47.47,89.3 45.58,91.19 38.83,91.19 38.07,90.42 36.93,90.42 36.42,89.92 31.97,89.92 30.7,88.65 27.53,88.65 26.89,89.28 22.78,89.28 v1(22.68,89.19)
  BOTTOM w0.127: JP11.4 17.88,104.14 19.15,102.87 19.15,97.41 19.83,96.72 19.83,92.04 v1(22.68,89.19)
NETJP12_2: length 66.4
  TOP w0.127: v1(34.66,106.43) 34.56,106.53 20.03,106.53 18.76,105.26 18.76,103.38 v1(18.13,102.74) ; v1(55.34,120.02) 56.1,120.02 57.25,118.87 U7.6
  BOTTOM w0.127: JP12.2 22.57,88.49 18.64,92.43 18.64,102.23 v1(18.13,102.74) ; v1(34.66,106.43) 35.5,106.43 42.61,113.54 48.86,113.54 v1(55.34,120.02)
NETJP13_2: length 75.2
  TOP w0.102: U5.B4 99.06,145.67 96.87,145.67
  TOP w0.127: JP13.2 R133.2 98.77,90.17 v1(97.5,91.44) ; 96.87,145.67 96.46,145.67 95.09,144.3 v4(93.87,144.3)
  BOTTOM w0.127: v4(93.87,144.3) 93.57,144.3 93.06,143.79 93.06,141.6 95.6,139.06 98.88,139.06 102.2,135.74 102.2,109.07 101.67,108.53 101.67,100.43 100.04,98.81 100.04,95.89 97.5,93.34 v1(97.5,91.44)
NETJP14_1: length 93.9
  TOP w0.127: U29.C6 v2(79.48,30.24)
  BOTTOM w0.127: v2(79.48,30.24) 78.97,29.73 78.97,28 78.41,27.45 77.27,27.45 72.97,31.75 71.04,31.75 70.66,32.13 56.92,32.13 42.89,46.15 42.89,62.23 35.91,69.22 29.94,69.22 26.23,72.92 26.23,78.64 25.11,79.76 JP14.1
NETJP14_2: length 174.8
  TOP w0.127: v1(94.71,13.69) 94.71,13.72 95.68,14.69 U35.3 ; v1(9.02,11.21) 9.96,12.15 U36.3
  BOTTOM w0.127: JP14.2 21.56,81.28 21.56,76.45 22.07,75.95 22.07,72.14 26.89,67.31 26.89,33.78 14.07,20.95 14.07,18.54 9.02,13.5 v1(9.02,11.21) 9.79,11.21 10.66,12.09 14.37,12.09 18.84,7.62 27.27,7.62 30.19,10.54 89.6,10.54 92.75,13.69 v1(94.71,13.69)
NETJP15_2: length 147.4
  TOP w0.127: v1(30.5,70.79) 31.59,71.88 50.41,71.88 51.17,72.64 52.52,72.64 53.03,73.15 55.7,73.15 56.03,73.48 60.42,73.48 61.23,74.3 85.54,74.3 88.59,71.25 v1(107.64,71.25) ; v1(107.66,106.35) 107.66,106.35 106.7,107.32 U10.17 ; v1(27.27,81.97) 27.27,81.66 26.51,80.9 18.38,80.9 JP15.2
  BOTTOM w0.127: v1(30.5,70.79) 30.5,71.2 27.35,74.35 27.35,81.89 v1(27.27,81.97) ; v1(107.64,71.25) 107.64,79.2 106.65,80.19 106.65,89.1 105.94,89.81 105.94,93.7 106.65,94.41 106.65,95.33 108.05,96.72 108.05,105.97 v1(107.66,106.35)
NETJP19_1: length 55
  TOP w0.127: R145.1 52.29,84.58 52.98,83.9 52.98,82.04 52.06,81.13 52.06,80.26 51.56,79.76 50.34,79.76 49.35,78.77 49.35,77.88 48.71,77.24 41.04,77.24 40,76.2 29.38,76.2 v1(29.36,76.23)
  BOTTOM w0.127: v1(29.36,76.23) 29.31,76.23 28.87,76.66 28.87,89.97 25.47,93.37 25.47,98.96 JP19.1
NETJP19_2: length 66.3
  TOP w0.127: U1.4 v1(20.67,157.42) 19.98,157.42 R21.2
  BOTTOM w0.127: JP19.2 22.57,100.84 24.35,102.62 25.37,102.62 26.09,103.34 26.09,109.52 24.86,110.74 24.86,124.21 25.19,124.54 25.19,126.82 22.78,129.24 22.78,132.87 23.69,133.78 23.69,141.01 25.37,142.68 25.37,152.53 20.67,157.23 v1(20.67,157.42)
NETL4_2: length 3.6
  TOP w0.508: L4.2 R219.2 R223.2
NETLD1_2: length 2.5
  TOP w0.127: LD1.2 R258.2
NETLD2_2: length 2.5
  TOP w0.127: LD2.2 R257.2
NETLD3_2: length 2.5
  TOP w0.127: LD3.2 R256.2
NETLD4_2: length 2.5
  TOP w0.127: LD4.2 R255.2
NETLD5_1: length 1.6
  TOP w0.127: R6.2 23.08,164.85 LD5.1
NETLD5_2: length 2.9
  TOP w0.127: LD5.2 21.43,167.26 21.18,167.51 T1.3
NETLD6_1: length 1.3
  TOP w0.127: 22.96,162.43 LD6.1
NETLD6_2: length 125.7
  TOP w0.127: v1(17.11,91.44) 17.24,91.31 28.92,91.31 31.08,93.47 47.09,93.47 47.97,94.36 49.09,94.36 49.85,95.12 49.85,96.55 50.51,97.21 54.25,97.21 54.71,97.66 54.71,100.46 R109.2 ; LD6.2 21.43,162.43 20.8,161.67 v1(20.8,160.78) 20.8,160.4 21.37,159.83 U1.3
  BOTTOM w0.127: v1(17.11,91.44) 17.05,91.5 17.05,101.85 15.97,102.94 15.97,105.28 17.05,106.37 17.05,108.11 20.54,111.6 20.54,111.63 23.72,114.81 23.72,126.21 22.27,127.66 22.27,141.43 24.99,144.15 24.99,152.4 20.16,157.23 20.16,157.73 20.92,158.5 20.92,160.66 v1(20.8,160.78)
NETLD7_1: length 1.8
  TOP w0.127: R165.1 LD7.1
NETLD8_2: length 2
  TOP w0.127: LD8.2 18.01,7.38 R253.2
NETLD8_3: length 1.8
  TOP w0.127: R254.2 19.51,7.74 LD8.3
NETLD8_4: length 6.8
  TOP w0.127: R252.1 16.86,7.75 16.86,5.59 17.37,5.08 18.64,5.08 19.51,4.2 LD8.4
NETLD9_1: length 45.4
  TOP w0.127: R268.2 80.23,48.77 80.23,43.43 80.87,42.8 92.5,42.8 96.87,38.43 96.87,36.47 97.68,35.66 103.65,35.66 111.09,43.1 LD9.1
NETLD9_2: length 48.5
  TOP w0.127: R110.2 81.12,50.8 82.73,49.19 U37.8 81.12,47.62 80.74,47.24 80.74,43.56 81.12,43.18 92.58,43.18 97.2,38.56 97.2,36.69 97.92,35.97 103.12,35.97 109.57,42.42 LD9.2
NETR1_2: length 2.6
  TOP w0.127: T1.1 23.49,166.12 R1.2 R261.2
NETR18_1: length 9.9
  TOP w0.102: 83.28,155.07 83.28,154.19 U2.B5
  TOP w0.127: R18.1 R22.2 80.74,157.61 83.28,155.07
NETR23_2: length 1.8
  TOP w0.127: U3.15 7.14,155.25 R23.2
NETR24_1: length 122.6
  TOP w0.127: R24.1 v1(23.72,155.32) ; R146.1 55.34,83.57 55.34,81.92 54.58,81.15 54.58,79.76 54.25,79.43 50.44,79.43 49.63,78.61 49.63,77.7 48.91,76.99 41.29,76.99 40.25,75.95 30.47,75.95 29.64,75.12 v1(28.84,75.12)
  BOTTOM w0.127: v1(28.84,75.12) 28.77,75.18 28.77,75.64 28.37,76.05 28.37,89.64 24.78,93.22 24.78,97.23 23.72,98.3 23.72,100.46 26.34,103.08 26.34,109.64 25.11,110.87 25.11,123.98 25.47,124.33 25.47,127.13 23.11,129.49 23.11,132.82 24.07,133.78 24.07,140.85 25.75,142.52 25.75,152.73 23.72,154.76 v1(23.72,155.32)
NETR24_2: length 1.7
  TOP w0.127: U4.15 20.34,155.01 R24.2
NETR25_2: length 5
  TOP w0.102: 104.06,151.13 104.06,149.66 103.46,149.06 U5.F7
  TOP w0.127: 104.06,151.13 104.06,153.75 R25.2
NETR29_2: length 3.3
  TOP w0.254: R29.2 21.18,147.83 R31.1 20.34,148.66 U4.6
NETR30_2: length 9.4
  TOP w0.254: U4.8 21.64,149.1 21.9,148.84 v1(21.94,148.84) ; U4.5 19.69,149.14 18.89,148.34 R30.2 19.65,147.83 R31.2
  BOTTOM w0.254: v1(21.94,148.84) 20.92,147.83 R30.2
NETR32_2: length 106.6
  TOP w0.102: 96.87,146.06 U5.A4
  TOP w0.127: v1(69.98,164.25) 71.34,162.89 74.19,162.89 76.3,160.78 76.3,151.51 84.93,142.88 87.09,142.88 88.23,141.73 v1(88.61,141.73) ; 96.87,146.06 96.37,146.06 95.35,145.03 R32.2 92.75,143.97 v1(91.99,143.97) ; v1(47.06,145.9) 46.83,145.67 46.83,131.84
  BOTTOM w0.127: v1(69.98,164.25) 69.72,164.52 69.72,168.4 69.16,168.96 65.14,168.96 64.74,168.55 64.74,167.03 64.18,166.47 54.86,166.47 54.48,166.09 54.48,162.33 52.7,160.55 52.7,159.82 53.13,159.38 53.13,149.17 49.86,145.9 v1(47.06,145.9) ; v1(88.61,141.73) 90.37,141.73 91.99,143.36 v1(91.99,143.97)
NETR33_2: length 6.8
  TOP w0.127: R33.2 58.01,142.49 ; U7.97 60.25,140.76 59.66,141.35 59.02,141.35 v1(58.77,141.1) 58.77,141.76
  BOTTOM w0.127: 59.28,142.24 59.28,141.6 v1(58.77,141.1)
NETR34_1: length 198.8
  TOP w0.127: v1(40.35,112.95) 40.35,117.98 37.18,121.16 37.18,129.03 44.93,136.78 44.93,146.94 46.83,148.84 56.74,148.84 59.28,146.3 62.07,146.3 62.45,145.92 62.58,145.92 R34.1 ; R119.2 26.13,92.84 25.62,92.33 18,92.33 17.37,92.96 16.61,92.96 v1(16.35,93.22) ; v1(35.2,107.42) 35.02,107.24 16.6,107.24 v1(15.85,106.49) ; v1(26.38,47.62) 29.81,47.62 31.57,45.87 46.98,45.87 50.95,41.91 55.59,41.91 57.37,43.69 59.91,43.69 R189.1
  BOTTOM w0.127: v1(15.85,106.49) 15.84,106.49 15.08,105.72 15.08,102.74 16.51,101.32 16.51,93.37 v1(16.35,93.22) 16.22,93.09 16.22,89.15 19.02,86.36 19.02,76.45 20.95,74.52 20.95,72.31 25.98,67.28 25.98,49.3 26.38,48.9 v1(26.38,47.62) ; v1(35.2,107.42) 35.2,107.96 40.19,112.95 v1(40.35,112.95)
NETR35_1: length 177.3
  TOP w0.127: R35.1 63.6,146.18 62.58,146.18 62.2,146.56 59.4,146.56 56.74,149.22 46.58,149.22 44.55,147.19 44.55,136.91 36.93,129.29 36.93,121.03 39.85,118.11 39.85,106.43 40.86,105.41 v1(40.86,103.89) ; R199.2 v1(84.04,39.24)
  BOTTOM w0.127: v1(40.86,103.89) 39.77,102.79 39.77,94.69 40.74,93.73 40.74,88.52 39.59,87.38 39.59,76.33 45.99,69.93 45.99,45.59 53.61,37.97 66.77,37.97 69.84,41.05 73.02,41.05 73.5,41.53 82.01,41.53 84.04,39.5 v1(84.04,39.24)
NETR36_2: length 7.4
  TOP w0.127: v1(60.73,143.18) 60.67,143.18 60.37,143.48 59.76,143.48 ; 59.4,142.37 R36.2 ; U7.96 60.75,140.77 59.79,141.73 59.79,141.99
  BOTTOM w0.127: v1(60.73,143.18) 60.01,143.89 R36.2
NETR37_1: length 1.9
  TOP w0.127: 61.18,142.37 61.18,143.51 R37.1
NETR38_2: length 5
  TOP w0.127: 70.45,141.86 70.45,141.22 71.75,139.93 U7.74 ; 70.07,142.47 70.07,143.89 R38.2
NETR39_1: length 6.9
  TOP w0.127: R39.1 72.49,143.76 R40.1 ; U7.73 72.25,140.46 73.63,141.83 SB3.2 73.25,142.49 73.25,143.76 73.12,143.89
NETR40_2: length 11.2
  TOP w0.127: R40.2 71.34,145.03 71.34,149.73 TS1.1
NETR41_2: length 10.3
  TOP w0.127: U5.F2 103.45,144.04 103.85,143.64 105.58,143.64 106.27,142.95 107.87,142.95 108.76,142.06 108.76,139.5 R43.1 R41.2
NETR42_2: length 4.2
  TOP w0.127: R42.2 121,140.34 SB7.1 120.31,138.37 U6.7
NETR48_2: length 9
  TOP w0.127: U7.70 76.42,136.15 77.44,137.16 R48.2 78.96,137.41 78.96,137.67 79.22,137.92 81.5,137.92 82.14,137.29
NETR50_2: length 8.9
  TOP w0.127: SB9.2 81.63,135.64 80.87,136.4 79.22,136.4 78.71,135.89 R50.2 78.7,135.65 U7.69
NETR53_2: length 148.7
  TOP w0.127: R53.2 46.32,130.43 41.24,130.43 38.64,127.83 38.64,121.35 41.75,118.24 41.75,109.35 v1(42.13,108.97) ; R205.2 v1(88.11,35.31)
  BOTTOM w0.127: v1(88.11,35.31) 86.84,36.58 86.84,38.35 82.77,42.42 65.04,42.42 61.11,38.48 53.87,38.48 46.7,45.64 46.7,61.47 47.85,62.61 47.85,69.47 45.49,71.83 45.49,76.12 44.6,77.01 44.6,94.34 44.32,94.61 44.32,103.61 45.61,104.9 45.61,106.96 43.61,108.97 v1(42.13,108.97)
NETR54_2: length 231.2
  TOP w0.127: v1(54.2,91.29) 54.35,91.44 54.71,91.44 55.85,92.58 61.06,92.58 61.69,93.22 93.21,93.22 v1(93.41,93.42) ; v1(30.55,66.37) 30.55,66.91 31.96,68.33 39.72,68.33 43.28,64.77 50.01,64.77 v1(50.64,65.41) ; v1(89.88,138.43) 89.88,138.3 84.04,132.46 82.14,132.46 81.06,131.38 81.06,131.25 R54.2 ; R258.1 v1(26.13,10.29)
  BOTTOM w0.127: v1(50.64,65.41) 50.64,67.06 51.33,67.74 51.33,72.44 54.45,75.56 54.45,85.37 53.97,85.85 53.97,91.06 v1(54.2,91.29) ; v1(26.13,10.29) 26.13,11.81 24.99,12.95 17.24,12.95 15.72,14.48 15.72,21.46 27.65,33.4 27.65,63.47 v1(30.55,66.37) ; v1(93.41,93.42) 93.41,95.08 96.36,98.03 96.36,107.59 100.17,111.4 100.17,133.6 98.83,134.95 95.9,134.95 92.42,138.43 v1(89.88,138.43)
NETR56_2: length 16.1
  TOP w0.127: 85.44,130.81 85.19,130.56 84.93,130.56 84.3,129.92 82.52,129.92 82.24,129.65 82.24,129.06 81.79,129.06 80.87,128.14 79.22,128.14 78.71,128.65 R56.2 77.69,127.89 77.69,125.73 76.61,124.65 U7.47
NETR59_2: length 115.6
  TOP w0.127: v1(107.59,105.64) 106.73,105.64 106.46,105.37 U10.20 ; v1(43.33,110.82) 43.33,111.4 42.51,112.22 42.51,118.75 39.47,121.79 39.47,126.24 R59.2 ; v1(48.1,90.7) 48.1,90.81 48.46,91.16 52.7,91.16 53.05,90.81 54.45,90.81 55.98,92.33 61.18,92.33 61.82,92.96 93.95,92.96 95.8,94.82 105.94,94.82 v1(106.14,94.61)
  BOTTOM w0.127: v1(107.59,105.64) 107.61,105.61 107.61,96.77 106.14,95.3 v1(106.14,94.61) ; v1(43.33,110.82) 43.35,110.8 43.35,109.82 47.11,106.06 47.11,93.47 48.1,92.48 v1(48.1,90.7)
NETR62_2: length 15.2
  TOP w0.127: U7.46 76.49,124.15 77.95,125.6 77.95,126.36 R62.2 78.71,127.51 79.09,127.89 81.12,127.89 81.38,128.14 84.68,128.14 84.8,128.02 SB15.2 SB14.2
NETR64_2: length 9.1
  TOP w0.127: 82.01,127 81.25,126.24 79.22,126.24 78.84,125.86 78.84,125.55 78.78,125.5 ; 78.71,125.22 77.95,125.22 76.37,123.65 U7.45
NETR65_2: length 12.4
  TOP w0.127: 82.26,125.73 82.65,126.11 85.06,126.11 SB17.2 ; U7.44 76.55,123.15 78.12,124.71 81.76,124.71 82.14,125.09 R65.2
NETR66_2: length 12.8
  TOP w0.127: SB19.2 81.38,124.46 79.09,124.46 78.71,124.08 R66.2 77.95,123.7 76.89,122.65 U7.43 ; 82.26,124.08 82.39,124.21 82.39,124.33 82.65,124.59 84.93,124.59 SB18.2
NETR67_2: length 79.9
  TOP w0.127: SW1.2 36.8,144.27 34.33,141.81 25.83,141.81 22.8,138.79 22.8,135.03 22.09,134.32 22.09,116.87 20.67,115.44 20.67,111 21.58,110.08 25.98,110.08 27.02,111.12 v1(31.34,111.12) ; R67.2 47.09,122.05 45.43,122.05 v1(45.18,122.3)
  BOTTOM w0.127: v1(31.34,111.12) 31.59,111.12 40.48,120.02 42.77,120.02 45.05,122.3 v1(45.18,122.3)
NETR68_2: length 12.6
  TOP w0.127: SB20.2 84.68,122.68 82.39,122.68 82.14,122.43 ; U7.42 74.33,122.17 R68.2 78.71,122.68 78.96,122.94 81.12,122.94 SB21.2
NETR71_1: length 4.6
  TOP w0.127: U9.1 108.64,117.86 107.03,117.86 R71.1 R74.2
NETR71_2: length 49.2
  TOP w0.127: R71.2 106.65,121.03 v1(106.65,121.54) ; v1(109.57,138.73) 109.52,138.68 106.9,138.68 106.78,138.56 104.36,138.56 102.84,140.08 101.57,140.08 101.06,140.59 87.34,140.59 SB8.1
  BOTTOM w0.127: v1(109.57,138.73) 109.57,138.56 107.16,136.14 106.14,136.14 105.89,135.89 105.89,127.51 107.28,126.11 107.28,122.17 v1(106.65,121.54)
NETR75_1: length 2.1
  TOP w0.127: U8.1 R75.1
NETR76_2: length 2.1
  TOP w0.127: R76.2 U8.4
NETR78_1: length 9.3
  TOP w0.254: 75.66,119.38 75.39,119.65 U7.37
  TOP w0.508: 75.66,119.38 78.2,116.84 81.12,116.84 ; 80.99,117.35 80.99,117.98 SB22.2
NETR81_2: length 12.5
  TOP w0.127: U7.36 72.23,117.62 v1(72.23,118.75) 72.36,118.87 75.41,118.87 78.58,115.7 R81.2
  BOTTOM w0.127: 73.15,117.83 v1(72.23,118.75)
NETR82_2: length 12.3
  TOP w0.254: U7.35 71.75,116.69 v1(72.1,116.33)
  TOP w0.508: R82.2 80.49,114.3 80.11,114.68 78.71,114.68 77.57,115.82 72.61,115.82 v1(72.1,116.33)
  BOTTOM w0.508: v1(72.1,116.33) 73.37,116.33
NETR89_1: length 134.9
  TOP w0.127: v1(44.88,103.12) 45.23,103.48 59.99,103.48 61.31,104.8 61.31,107.06 62.45,108.2 62.45,110.74 61.56,111.63 R89.1 ; R201.2 v1(88.11,36.58)
  BOTTOM w0.127: v1(44.88,103.12) 44.57,102.82 44.57,94.74 44.85,94.46 44.85,77.27 45.84,76.28 45.84,71.98 48.36,69.47 48.36,62.48 47.06,61.19 47.06,45.67 53.99,38.73 60.98,38.73 64.69,42.44 64.69,42.55 64.94,42.8 74.7,42.8 74.95,43.05 82.77,43.05 87.22,38.61 87.22,37.47 v1(88.11,36.58)
NETR90_1: length 153.1
  TOP w0.127: R90.1 63.34,111.63 v1(64.23,110.74) ; v1(46.53,68.83) 50.51,68.83 51.02,68.33 54.2,68.33 54.96,69.09 65.25,69.09 v1(67.15,70.99) ; R208.2 v1(88.11,32.77)
  BOTTOM w0.127: v1(46.53,68.83) 46.32,68.63 46.32,45.64 53.74,38.23 66.66,38.23 70.6,42.16 82.52,42.16 86.46,38.23 86.46,34.42 v1(88.11,32.77) ; v1(67.15,70.99) 67.33,71.17 72.03,71.17 73.32,72.47 73.32,74.88 74.52,76.07 74.52,81.71 67.02,89.2 67.02,91.62 64.36,94.28 64.36,98.81 61.82,101.35 61.82,103 61.26,103.56 61.26,108.53 63.47,110.74 v1(64.23,110.74)
NETR91_1: length 44
  TOP w0.127: v1(64.99,110.74) 64.74,111 R91.1 ; v1(70.71,86.61) 71.09,86.23 76.55,86.23 79.02,88.7 U14.12 80.54,88.7 R127.2
  BOTTOM w0.127: v1(70.71,86.61) 70.07,86.61 67.35,89.33 67.35,91.69 64.61,94.44 64.61,98.93 62.07,101.47 62.07,103.15 61.51,103.71 61.51,108.28 63.47,110.24 64.48,110.24 v1(64.99,110.74)
NETR97_2: length 18.1
  TOP w0.127: U7.26 67.25,116.39 70.71,112.93 70.71,110.49 72.36,112.14 74.52,112.14 v1(74.64,112.01)
  BOTTOM w0.127: v1(74.64,112.01) 74.64,114.05 76.14,115.54 76.91,115.54
NETR98_2: length 18.2
  TOP w0.127: U7.27 67.75,116.37 71.34,112.78 74.9,112.78 75.41,112.27 v1(75.41,111.51) 73.25,111.51 R98.2
  BOTTOM w0.127: v1(75.41,111.51) 75.41,113.39 75.94,113.92 SB36.2
NETR99_2: length 16
  TOP w0.127: 73.76,110.62 74.01,110.87 75.79,110.87 v1(76.17,111.25) 76.17,112.52 75.28,113.41 71.22,113.41 68.25,116.38 U7.28
  BOTTOM w0.127: 76.91,112.24 76.91,111.99 v1(76.17,111.25)
NETR103_1: length 10.2
  TOP w0.127: SB26.1 R103.1 51.15,113.28 54.75,116.88 U7.1
NETR104_1: length 123.8
  TOP w0.127: U7.2 55.25,116.75 51.91,113.41 51.91,111.12 R104.1 51.91,109.6 51.91,107.31 v1(50.26,105.66) ; v1(49.57,72.34) 50.39,73.15 52.27,73.15 52.77,73.66 55.44,73.66 55.77,73.99 60.17,73.99 60.98,74.8 86.18,74.8 88.46,72.52 112.11,72.52 113,73.41 113,78.87 R154.2
  BOTTOM w0.127: v1(50.26,105.66) 51.66,104.27 51.66,94.39 49.63,92.35 49.63,84.84 51.68,82.78 51.68,77.32 49.93,75.56 49.93,72.69 v1(49.57,72.34)
NETR105_1: length 133.2
  TOP w0.127: v1(82.14,39.37) 81.76,38.99 R198.2 ; v1(42.89,106.81) 42.89,106.68 45.56,104.01 59.76,104.01 60.55,104.8 R105.1
  BOTTOM w0.127: v1(42.89,106.81) 39.47,103.38 39.47,94.56 40.43,93.6 40.43,88.98 39.21,87.76 39.21,76.15 45.54,69.82 45.54,45.67 53.61,37.59 66.85,37.59 70,40.74 73.22,40.74 73.63,41.15 81.58,41.15 82.14,40.59 v1(82.14,39.37)
NETR106_1: length 153.8
  TOP w0.127: R222.1 87.34,28.19 87.73,28.57 v1(87.85,28.57) ; R106.1 60.93,107.82 60.93,104.8 59.89,103.76 45.05,103.76 41.37,107.44 v1(41.37,107.7)
  BOTTOM w0.127: v1(87.85,28.57) 87.14,28.57 86.84,28.88 86.84,33.15 86.07,33.91 86.07,35.81 84.05,37.83 78.19,37.83 77.46,38.56 77.46,40.06 77.08,40.44 70.17,40.44 66.95,37.21 53.61,37.21 45.05,45.77 45.05,67.01 44.24,67.82 41.98,67.82 37.18,72.62 37.18,94.11 36.98,94.31 36.98,105.44 39.24,107.7 v1(41.37,107.7)
NETR107_1: length 197.2
  TOP w0.127: U30.24 59.53,26.42 58.64,25.53 55.21,25.53 53.18,23.5 53.18,18.29 56.55,14.92 58.83,14.92 59.91,13.84 v1(59.91,9.14) ; v1(109.87,95.35) 109.19,96.04 96.49,96.04 92.48,100.05 84.19,100.05 82.9,101.35 80.87,101.35 R107.1
  BOTTOM w0.127: v1(59.91,9.14) 60.55,9.78 74.77,9.78 75.13,9.42 78.73,9.42 78.96,9.65 90.52,9.65 93.06,12.19 97.61,12.19 98.85,13.44 98.85,14.3 104.13,19.58 104.13,39.78 112.36,48.01 112.36,57.53 114.88,60.05 114.88,68.81 116.48,70.41 116.48,71.15 117.82,72.49 117.82,87.25 115.79,89.28 111.58,89.28 109.57,91.29 109.57,95.05 v1(109.87,95.35)
NETR112_2: length 2.2
  TOP w0.127: U11.1 6.68,99.34 R112.2
NETR113_1: length 3.3
  TOP w0.127: R113.1 5.81,96.65 5.81,95.76 5.59,95.54 U11.5
NETR114_1: length 3.3
  TOP w0.127: U12.3 24.22,95.25 R116.1 24.86,95.89 R114.1
NETR117_1: length 4.9
  TOP w0.127: R118.1 R119.1 24.99,93.47 R117.1 24.73,94.75 U12.2
NETR122_1: length 1.5
  TOP w0.127: U13.2 70.2,90.81 R122.1
NETR123_2: length 8.1
  TOP w0.127: R123.2 v1(58.01,91.69) 59.03,91.69 T2.4 ; v1(58.01,86.74) 57.75,86.49 R135.1
  BOTTOM w0.127: v1(58.01,86.74) v1(58.01,91.69)
NETR125_1: length 4.2
  TOP w0.127: U15.13 51.5,89.95 R125.1 51.53,90.3 51.23,90.6 U15.14
NETR125_2: length 6.3
  TOP w0.127: R125.2 52.17,90.42 v1(52.17,90.55) ; R132.1 v1(50.99,87.63) 50.71,87.35 U15.9
  BOTTOM w0.127: v1(50.99,87.63) 51.02,87.63 51.28,87.88 51.28,89.66 v1(52.17,90.55)
NETR129_1: length 9.3
  TOP w0.127: U15.10 48.06,88 44.65,84.58 43.91,84.58 R129.1 R136.2
NETR129_2: length 7.9
  TOP w0.127: 44.29,85.22 44.93,85.86 44.93,89.95 ; U15.1 44.93,90.6 45.1,90.42 45.1,90.12 44.93,89.95 ; 44.93,89.95 U15.2
NETR130_1: length 2
  TOP w0.127: R130.1 81.04,88.05 U14.11
NETR132_2: length 20.5
  TOP w0.127: U13.1 68.09,89.41 64.03,89.41 63.65,89.03 55.59,89.03 54.2,87.63 R132.2 52.55,87.63 51.91,87 50.77,87 50.47,86.7 U15.8
NETR134_1: length 1.8
  TOP w0.127: R134.1 81.53,87.4 U14.10
NETR136_1: length 4.5
  TOP w0.127: U15.7 43.23,86.7 42.64,86.11 42.26,86.11 R136.1 42.01,86.36 42.99,87.35 U15.6
NETR137_1: length 23.4
  TOP w0.127: 60.42,87.25 T3.2 63.21,87.25 R137.1 62.93,86.71 62.61,86.71 62.2,86.3 T3.1 T3.6 ; 60.42,87.25 T3.5 ; 60.42,87.25 60.42,88.44 60.09,88.77 55.72,88.77 55.02,88.07 55.02,87.25 53.75,85.98 51.07,85.98 49.68,84.58 R144.1
NETR143_1: length 64.8
  TOP w0.127: v1(59.02,41.78) 56.36,39.12 56.36,34.16 R210.2 ; R143.1 v1(47.85,84.58)
  BOTTOM w0.127: v1(47.85,84.58) 47.85,82.3 47.09,81.53 47.09,73.03 49.93,70.18 49.93,63.55 49.37,62.99 49.37,61.04 48.41,60.07 48.41,46.18 52.29,42.29 54.27,42.29 55.31,41.25 58.49,41.25 v1(59.02,41.78)
NETR156_2: length 115.6
  TOP w0.127: v1(48.58,72.39) 48.84,72.64 49.19,72.64 49.96,73.41 52.14,73.41 52.65,73.91 55.31,73.91 55.65,74.24 59.81,74.24 60.62,75.06 86.38,75.06 88.51,72.92 112.01,72.92 112.62,73.53 112.62,77.85 R156.2
  BOTTOM w0.127: v1(48.58,72.39) 48.3,72.67 48.3,75.44 49.42,76.56 49.42,83.9 48.86,84.45 48.86,93.19 49.4,93.73 49.4,101.57 48.48,102.49 48.48,108.58 50.9,111 53.05,111 SB40.2 53.72,111.66
NETR167_2: length 6.9
  TOP w0.127: 111.35,54.86 111.35,56.9 107.96,56.9 107.71,56.64 T4.1
NETR168_1: length 1.5
  TOP w0.127: R168.1 64.62,56.27 U23.44
NETR172_2: length 3.6
  TOP w0.127: U23.2 60.2,52.8 59.53,53.47 59.53,54.23 R172.2
NETR174_2: length 2.8
  TOP w0.127: U23.3 60.19,52.3 R174.2
NETR177_1: length 4.3
  TOP w0.127: 111.35,52.07 109.3,52.07 T4.2
NETR184_1: length 2.1
  TOP w0.127: U37.5 R184.1
NETR187_1: length 1.8
  TOP w0.127: U23.20 66.12,45.1 R187.1
NETR188_1: length 4.2
  TOP w0.127: U23.12 61.02,46.58 59.72,45.28 59.72,45.15 R188.1
NETR189_2: length 2.9
  TOP w0.127: U25.2 61.95,42.67 61.56,43.05 61.56,43.81 R189.2
NETR193_2: length 1.1
  TOP w0.127: U25.3 61.82,42.17 61.56,41.91
NETR197_2: length 7.2
  TOP w0.127: U29.G2 v2(81.48,32.74) ; R197.2 84.8,37.21 84.8,36.45 84.42,36.07 84.19,36.07 v1(83.61,35.48)
  BOTTOM w0.127: v1(83.61,35.48) 81.48,33.36 v2(81.48,32.74)
NETR198_1: length 6
  TOP w0.127: U29.E4 v2(80.48,31.74) ; v1(81.14,36.05) 81.2,36.05 81.76,36.6 R198.1
  BOTTOM w0.127: v2(80.48,31.74) 80.56,31.82 80.56,34.7 81.14,35.28 v1(81.14,36.05)
NETR199_1: length 6.7
  TOP w0.127: R199.1 81.83,34.62 v1(81.15,34.62) ; U29.G3 v2(80.98,32.24)
  BOTTOM w0.127: v1(81.15,34.62) 80.84,34.32 80.84,32.38 v2(80.98,32.24)
NETR200_1: length 8.7
  TOP w0.127: R200.1 82.9,36.83 81.37,35.3 80.97,35.3 v1(80.69,35.58) ; U29.D5 v2(80.48,31.24) U29.D4
  BOTTOM w0.127: v1(80.69,35.58) 80.18,35.07 80.18,33.12 80.33,32.97 80.33,32.08 80.16,31.9 80.16,31.59 80.48,31.27 v2(80.48,31.24)
NETR201_1: length 5.4
  TOP w0.127: R201.1 84.8,35.94 84.8,35.18 84.22,34.59 84.22,34.47 82.24,32.49 U29.G1
NETR202_2: length 1.6
  TOP w0.457: U28.3 49.06,36.13 R202.2
NETR203_1: length 3.4
  TOP w0.457: R203.1 R204.2 U28.5
NETR205_1: length 5.3
  TOP w0.127: v1(84.04,33.53) 84.68,34.16 84.68,34.54 R205.1 ; U29.F2 v2(81.98,32.24)
  BOTTOM w0.127: v1(84.04,33.53) 83.41,33.53 82.12,32.24 v2(81.98,32.24)
NETR206_1: length 1.6
  TOP w0.457: U28.1 49.06,34.23 R206.1
NETR208_1: length 5.2
  TOP w0.127: R208.1 85.19,32.51 v1(84.55,32.51) ; U29.E3 v2(80.98,31.74)
  BOTTOM w0.127: v2(80.98,31.74) 81.12,31.88 82.11,31.88 82.65,32.41 84.45,32.41 v1(84.55,32.51)
NETR210_1: length 2.8
  TOP w0.127: R210.1 56.99,30.73 U30.26
NETR211_2: length 20.4
  TOP w0.127: R211.2 v1(54.58,30.48) 54.58,28.93 U30.28
  BOTTOM w0.127: TP14.1 50.26,16.13 53.05,18.92 53.05,25.15 54.58,26.67 v1(54.58,30.48)
NETR212_2: length 19.6
  TOP w0.127: R212.2 55.72,30.99 v1(55.72,30.48) U30.27
  BOTTOM w0.127: TP15.1 53.56,24.77 55.72,26.92 v1(55.72,30.48)
NETR213_1: length 32.4
  TOP w0.127: R213.1 60.8,31.24 U30.23 60.8,26.54 62.83,24.51 v1(67.41,24.51) ; v1(84.55,19.81) U33.10
  BOTTOM w0.127: v1(67.41,24.51) 69.95,21.97 76.04,21.97 76.8,21.21 83.15,21.21 84.55,19.81 v1(84.55,19.81)
NETR214_2: length 34.9
  TOP w0.127: v1(83.41,17.14) 83.13,17.14 82.88,17.4 U33.6 ; U30.20 v1(64.61,30.48) 64.74,30.61 R214.2
  BOTTOM w0.127: v1(83.41,17.14) 82.52,16.26 69.44,16.26 63.6,22.1 63.6,29.46 v1(64.61,30.48)
NETR215_2: length 35.7
  TOP w0.127: R215.2 v1(65.75,30.35) 65.75,28.93 65.88,28.8 ; v1(84.55,17.91) 84.15,18.31 U33.7
  BOTTOM w0.127: v1(84.55,17.91) 84.3,17.65 82.52,17.65 81.5,16.64 70.2,16.64 63.98,22.86 63.98,28.57 v1(65.75,30.35)
NETR216_2: length 26.5
  TOP w0.127: U30.1 v1(54.45,20.95) ; R216.2 v1(66.77,30.48)
  BOTTOM w0.127: v1(54.45,20.95) 55.98,19.43 61.69,19.43 63.09,20.83 63.09,30.61 63.72,31.24 66.01,31.24 v1(66.77,30.48)
NETR217_2: length 3.9
  TOP w0.127: R218.1 R217.2 67.79,30.23 67.15,29.59 U30.18
NETR222_2: length 9.7
  TOP w0.127: U29.D3 v2(80.98,31.24) ; R222.2 84.93,28.19 v1(84.48,28.64)
  BOTTOM w0.127: v2(80.98,31.24) 80.99,31.24 81.35,31.6 82.29,31.6 82.75,32.05 85.01,32.05 85.26,31.8 85.26,29.42 v1(84.48,28.64)
NETR228_2: length 20
  TOP w0.127: R228.2 v1(90.14,22.99) R229.2 89.88,21.97 U32.2 ; U33.22 v1(78.84,19.31)
  BOTTOM w0.127: v1(78.84,19.31) 79.98,18.16 83.79,18.16 84.17,18.54 87.22,18.54 88.23,19.56 88.23,22.1 89.12,22.99 v1(90.14,22.99)
NETR230_2: length 3
  TOP w0.127: R231.2 R230.2 80.38,22.84 U33.18
NETR232_2: length 3.3
  TOP w0.127: U33.23 78.19,18.81 R233.2 77.57,19.43 R232.2
NETR234_2: length 1.6
  TOP w0.457: U34.3 50.07,18.6 R234.2
NETR235_1: length 3.4
  TOP w0.457: R235.1 R236.2 U34.5
NETR235_2: length 16.2
  TOP w0.508: R235.2 39.21,19.18 35.15,15.11 RV1.1
NETR237_2: length 3.3
  TOP w0.127: U33.24 78.22,18.31 R237.2 77.82,16.76 R243.2
NETR238_1: length 3
  TOP w0.127: U35.2 95.68,15.54 95.09,16.13 95.09,16.87 95.5,17.27 R238.1
NETR239_1: length 1.5
  TOP w0.127: U32.9 88.88,17.41 R239.1
NETR240_1: length 1.6
  TOP w0.457: U34.1 50.07,16.7 R240.1
NETR241_1: length 39.4
  TOP w0.127: v1(58.26,16.89) 57.37,16.89 R241.1 56.99,17.27 U30.3 ; v1(85.31,17.78) 84.3,18.8 83.59,18.8 U33.8
  BOTTOM w0.127: v1(85.31,17.78) 85.31,14.35 84.3,13.34 69.82,13.34 64.48,18.67 60.04,18.67 v1(58.26,16.89)
NETR255_1: length 76.9
  TOP w0.127: v1(90.65,16.76) 89.88,17.53 U32.11 ; R255.1 v1(21.56,10.16)
  BOTTOM w0.127: v1(21.56,10.16) 23.21,8.51 26.51,8.51 30.19,12.19 88.11,12.19 90.65,14.73 v1(90.65,16.76)
NETR257_1: length 71
  TOP w0.127: v1(24.61,10.16) R257.1 ; U32.8 87.48,18.93 87.36,18.81 87.36,18.16 87.1,17.91 v1(87.09,17.91)
  BOTTOM w0.127: v1(87.09,17.91) 86.96,17.78 86.96,14.1 85.82,12.95 29.69,12.95 26.26,9.53 25.24,9.53 v1(24.61,10.16)
NETR260_1: length 20.3
  TOP w0.127: R260.1 v1(88.87,35.31) ; U33.11 84.54,20.31 v1(84.8,20.57)
  BOTTOM w0.127: v1(88.87,35.31) 88.87,27.94 89.38,27.43 89.38,24.89 87.22,22.73 87.22,21.72 86.71,21.21 85.44,21.21 v1(84.8,20.57)
NETR260_2: length 2.4
  TOP w0.127: T6.1 89.93,36.75 R260.2 R267.1
NETR263_2: length 4.9
  TOP w0.127: U6.5 119.05,137.07 R263.2 120.75,135.38 121.89,135.38 R265.1
NETR264_2: length 4.7
  TOP w0.127: U6.6 119.8,137.72 R264.2 120.87,138.18 121.76,138.18 R266.1
NETSB9_1: length 42.5
  TOP w0.127: 84.04,135.25 88.23,139.45 100.43,139.45 100.81,139.06 102.33,139.06 103.85,137.54 107.41,137.54 107.92,137.03 110.59,137.03 111.35,136.27 111.35,135.64 110.84,135.13 110.84,133.73 113.13,131.44 113.13,129.41 111.92,128.21 111.92,126.68 111.47,126.24 U9.6
NETSB12_1: length 40.7
  TOP w0.127: v1(112.62,132.74) 113.61,131.75 113.61,128.5 112.74,127.64 U9.5 ; 87.34,131.19 87.34,132.97 90.39,136.02 90.39,136.96 91.87,138.43 99.28,138.43 99.79,137.92 101.95,137.92 103.6,136.27 110.23,136.27 v1(110.51,135.99)
  BOTTOM w0.127: v1(112.62,132.74) 112.11,132.74 111.09,133.76 111.09,135.41 v1(110.51,135.99)
NETSB14_1: length 67.2
  TOP w0.127: U9.2 110.2,117.22 112.87,114.55 112.87,112.14 112.24,111.51 110.46,111.51 108.3,109.35 106.39,109.35 106.01,109.73 103.35,109.73 102.71,109.09 v1(96.36,109.09) ; 87.23,129.04 88.11,129.04 89.76,130.68 89.76,133.73 v1(90.77,134.75)
  BOTTOM w0.127: v1(96.36,109.09) 99.28,112.01 99.28,132.92 98.14,134.06 94.23,134.06 93.54,134.75 v1(90.77,134.75)
NETSB18_1: length 48.6
  TOP w0.127: U9.3 111.47,116.97 113.51,114.94 113.51,111.84 112.44,110.77 110.99,110.77 108.93,108.71 106.01,108.71 105.63,109.09 103.73,109.09 102.97,108.33 95.98,108.33 v1(95.22,109.09) ; SB18.1 88.74,124.08 91.15,121.67 91.15,115.82 90.39,115.06 90.39,113.41 92.68,111.12 v1(94.46,111.12)
  BOTTOM w0.127: v1(94.46,111.12) 95.22,110.36 v1(95.22,109.09)
NETSB21_1: length 50.7
  TOP w0.127: U9.7 110.2,126.11 v1(109.59,126.72) ; v1(107.89,115.04) 107.31,114.45 104.18,114.45 103.47,113.74 103.47,112.14 101.82,110.49 94.84,110.49 94.71,110.36 92.68,110.36 88.87,114.17 88.87,115.06 90.14,116.33 90.14,120.9 89.88,121.16 84.42,121.16 83.92,121.67
  BOTTOM w0.127: v1(107.89,115.04) 109.14,116.28 109.14,125.3 109.59,125.76 v1(109.59,126.72)
NETT3_3: length 10
  TOP w0.127: T3.3 65.88,88.2 66.31,87.77 U16.4 v1(66.99,88.42) ; U13.4 66.39,90.85 v1(66.39,90.81)
  BOTTOM w0.127: v1(66.99,88.42) 66.97,88.42 66.24,89.16 66.24,90.65 v1(66.39,90.81)
NETTP19_1: length 50.5
  TOP w0.127: U23.21 v1(66.62,47.38)
  BOTTOM w0.127: v1(66.62,47.38) 66.46,47.38 66.16,47.68 66.16,50.77 66.74,51.36 66.74,57.25 68.55,59.05 80.33,59.05 91.65,70.37 TP19.1
NETU14_3: length 6.9
  TOP w0.127: U14.3 73,90 72.76,89.76 72.76,88.8 71.09,87.12 U16.2
NETU23_13: length 5.3
  TOP w0.127: U23.13 62.62,45.3 64.48,43.43 64.48,42.93 64.74,42.67 U25.7
OPAMP1_INM: length 21.9
  TOP w0.508: 91.44,80.64 91.54,80.64 94.84,83.95 94.84,90.42 96.49,92.08 97.89,92.08 99.16,90.81 R121.2 R120.1 102.2,91.18 RV2.1
OPAMP1_INP: length 40.7
  TOP w0.508: R83.2 84.17,112.39 84.68,112.9 89.5,112.9 92.55,109.86 94.84,109.86 94.96,109.98 102.08,109.98 104.24,112.14 v1(105.89,112.14) ; 107.03,126.36 107.03,125.98 v1(106.65,125.6)
  BOTTOM w0.508: v1(106.65,125.6) 105.89,124.84 v1(105.89,112.14)
OPAMP1_OUT: length 50.3
  TOP w0.508: R111.1 76.8,101.85 83.28,101.85 84.45,100.69 92.65,100.69 96.84,96.49 110.86,96.49 111.6,95.76 TP9.1 RV2.2 106.99,93.48 RV2.3
OSC_IN: length 10.1
  TOP w0.203: U23.5 59.92,51.3 C88.2 58.13,51.82 54.58,51.82 53.82,52.58 X3.2
OSC_OUT: length 11.6
  TOP w0.203: X3.1 53.82,49.4 54.96,50.55 58.13,50.55 C89.2 59.15,50.8 U23.6
PA0: length 36.8
  TOP w0.127: CN7.37 96.01,113.79 v1(96.67,114.45) ; 80.97,112.55 81.76,113.33 v1(82.19,113.33) 82.26,113.41 85.19,113.41 87.09,115.32 v1(87.6,115.32)
  TOP w0.254: 71.09,115.95 71.09,116.46 71.25,116.62 U7.34
  TOP w0.508: R83.1 79.22,113.92 78.45,113.92 77.18,115.19 71.85,115.19 71.09,115.95
  BOTTOM w0.127: v1(87.6,115.32) 87.85,115.57 89.38,115.57 89.5,115.7 91.92,115.7 92.42,115.19 92.42,113.92 93.06,113.28 95.5,113.28 v1(96.67,114.45) ; 82.39,115.82 82.39,113.54 v1(82.19,113.33)
PA4: length 31.6
  TOP w0.127: U7.40 75.8,121.15 76.68,120.27 v1(77.57,120.27) 78.2,119.63 R73.1 ; v1(98.04,116) 97.99,115.95 97.99,115.39 98.27,115.11 98.27,114.68 99.16,113.79 CN7.38
  BOTTOM w0.127: v1(77.57,120.27) 86.96,120.27 88.36,118.87 92.45,118.87 95.98,115.34 97.38,115.34 v1(98.04,116)
PA5: length 28.4
  TOP w0.127: U7.41 76.06,121.65 76.8,120.9 v1(77.57,120.9) R69.1 ; CN7.35 95.98,115.06 96.77,115.85 v1(96.79,115.85)
  BOTTOM w0.127: v1(77.57,120.9) 86.84,120.9 88.49,119.25 92.55,119.25 95.95,115.85 v1(96.79,115.85)
PA11: length 74.6
  TOP w0.155: v1(28.52,132.87) 29.76,134.11 CN6.6 ; v1(29.35,163.29) 29.63,163.57 29.63,164.79 D1.D3 29.44,164.85 29.18,164.59 28.29,164.59 R3.2 ; U7.103 57.25,138.56 57.19,138.5 57.19,137.93 v1(57.33,137.79)
  BOTTOM w0.155: v1(57.33,137.79) 57.19,137.65 57.19,137.23 56.74,136.78 35.2,136.78 30.09,131.67 29.15,131.67 28.7,132.12 28.7,132.68 v1(28.52,132.87) 28.54,132.87 28.75,133.07 28.75,133.29 28.61,133.43 27.4,133.43 26.26,134.57 26.26,138.66 29.63,142.03 29.63,163.01 v1(29.35,163.29)
PA12: length 76
  TOP w0.155: v1(30.3,163.29) 30.01,163.57 30.01,164.79 D1.C3 30.07,164.84 30.45,164.47 30.45,164.34 30.83,163.96 31.97,163.96 R4.2 ; v1(56.67,137.79) 56.81,137.93 56.81,138.48 56.75,138.54 U7.104 ; v1(29.41,132.82) 28.92,132.33 28.16,132.33 27.65,132.84 CN6.7
  BOTTOM w0.155: v1(56.67,137.79) 56.81,137.65 56.81,137.39 56.58,137.16 55.33,137.16 55.12,137.36 54.81,137.36 54.61,137.16 54.3,137.16 54.1,137.36 53.79,137.36 53.58,137.16 53.27,137.16 53.07,137.36 52.76,137.36 52.56,137.16 35.04,137.16 33.04,135.16 32.67,135.16 32.45,134.94 32.45,134.57 32.23,134.35 31.85,134.35 31.63,134.13 31.63,133.75 31.42,133.54 31.04,133.54 30.82,133.32 30.82,132.94 29.93,132.05 29.31,132.05 29.08,132.28 29.08,132.49 v1(29.41,132.82) 29.13,133.1 29.13,133.45 28.77,133.81 27.56,133.81 26.64,134.73 26.64,138.5 30.01,141.87 30.01,163.01 v1(30.3,163.29)
PA13: length 274.1
  TOP w0.127: v1(56.23,140.36) 56.25,140.34 U7.105 ; U24.7 72.1,48.11 72.1,47.5 71.74,47.14 v1(71.74,47.12) 71.6,47.12 70.83,47.88 70.83,48.39 70.43,48.8 U23.27 ; RS1.13 112.47,88.12 113.07,88.72 v1(113.07,88.77) ; v1(38.45,67.56) 44.55,61.47 v1(48.41,61.47) ; v1(28.16,134.62) 27.65,134.11 CN6.5 24.35,134.11 22.85,132.61 22.85,116.38 21.61,115.14 21.61,111.66 v1(22.02,111.25)
  BOTTOM w0.127: v1(28.16,134.62) 27.53,135.25 27.53,137.92 28.72,139.12 54.76,139.12 55.34,139.7 55.57,139.7 v1(56.23,140.36) ; v1(48.41,61.47) 47.47,60.53 47.47,45.97 51.91,41.53 53.18,41.53 54.32,40.39 59.79,40.39 61.03,41.63 61.03,44.32 62.83,46.13 67.89,46.13 68.52,46.76 68.52,47.78 68.32,47.98 68.09,47.98 67.91,48.17 67.91,48.58 68.24,48.92 68.83,48.92 70.5,47.25 71.61,47.25 v1(71.74,47.12) 71.74,47.12 72.61,47.12 74.14,48.64 95.09,48.64 97.25,46.48 108.3,46.48 111.6,49.78 111.6,57.91 114.04,60.35 114.04,69.27 117.44,72.67 117.44,86.69 115.36,88.77 v1(113.07,88.77) ; v1(22.02,111.25) 22.02,110.95 21.15,110.08 21.15,103.2 20.03,102.08 20.03,97.56 22.14,95.45 22.14,92.33 26.23,88.24 26.23,79.32 26.61,78.94 26.61,73.18 30.19,69.6 36.42,69.6 v1(38.45,67.56)
PA14: length 276.7
  TOP w0.127: v1(22.83,110.9) 22.83,111.25 22.52,111.56 22.42,111.56 21.99,111.99 21.99,114.96 23.54,116.51 23.54,130.78 24.33,131.57 v1(24.33,131.62) ; CN6.8 32.73,132.84 v1(33.5,133.6) ; v1(39.64,67.08) 44.75,61.98 48.58,61.98 v1(48.74,62.13) ; v1(57.73,136.47) 57.6,136.35 56.92,136.35 56.11,137.15 U7.109 ; U23.15 63.62,48.47 64.18,49.02 67.48,49.02 v1(67.58,48.92) 67.58,48.37 67.97,47.98 68.8,47.98 68.95,48.13 69.56,48.13 U23.26 ; RS1.11 112.5,87.62 112.62,87.73 112.64,87.73 112.97,88.06 v1(113.15,88.06)
  BOTTOM w0.127: v1(48.74,62.13) 48.94,61.93 48.94,61.21 47.97,60.25 47.97,46.15 52.22,41.91 53.66,41.91 54.78,40.79 59.51,40.79 60.57,41.86 60.57,44.42 62.66,46.51 66.8,46.51 67.51,47.22 67.51,48.84 v1(67.58,48.92) 68.07,49.4 68.9,49.4 70.05,48.26 72.99,48.26 73.76,49.02 95.4,49.02 96.08,48.34 109.39,48.34 111.22,50.16 111.22,59.05 111.6,59.44 111.6,67.44 116.55,72.39 116.55,83.34 115.23,84.66 115.23,87.5 114.67,88.06 v1(113.15,88.06) ; v1(24.33,131.62) 24.83,132.13 27.76,132.13 28.9,130.99 30.88,130.99 v1(33.5,133.6) 35.91,136.02 56.99,136.02 57.37,136.4 57.65,136.4 v1(57.73,136.47) ; v1(22.83,110.9) 21.61,109.68 21.61,103.07 20.47,101.93 20.47,97.71 22.52,95.66 22.52,92.66 26.66,88.52 26.66,81.66 27.02,81.31 27.02,73.51 30.5,70.03 36.7,70.03 v1(39.64,67.08)
PB2: length 34.7
  TOP w0.127: 82.26,130.94 80.99,129.67 79.47,129.67 R54.1 77.44,129.16 v1(77.44,128.7) 77.44,125.86 76.68,125.09 75.38,125.09 75.33,125.15 U7.48 ; CN7.13 96.59,129.03 v1(96.82,128.8)
  BOTTOM w0.127: v1(77.44,128.7) 77.62,128.52 95.85,128.52 96.13,128.8 v1(96.82,128.8)
PB6: length 59.2
  TOP w0.127: CN6.40 30.45,112.52 v1(29.69,111.76) ; v1(50.95,123.44) 51.15,123.65 U7.136 ; R118.2 22.07,93.6 22.07,97.54 22.45,97.92 26.89,97.92 v1(28.04,96.77)
  BOTTOM w0.127: v1(28.04,96.77) 28.16,96.9 28.16,99.81 29.02,100.67 29.02,111.09 v1(29.69,111.76) 30.32,112.39 30.32,113.41 38.45,121.54 41.24,121.54 41.75,122.05 41.75,123.7 42.13,124.08 50.31,124.08 v1(50.95,123.44)
PC3: length 55.5
  TOP w0.127: v1(98.04,116.76) 98.49,116.31 98.49,115.72 99.16,115.06 CN7.36 ; R94.1 76.8,111 76.8,112.9 75.66,114.05 71.09,114.05 68.75,116.38 U7.29 68.75,118.8 67.41,120.14 v1(67.15,120.14)
  BOTTOM w0.127: v1(98.04,116.76) 97.58,116.31 96.13,116.31 92.81,119.63 88.74,119.63 86.07,122.3 67.91,122.3 67.28,121.67 67.28,120.27 v1(67.15,120.14)
PC13: length 182.2
  TOP w0.127: v1(55.34,120.78) 56.1,120.78 57.75,119.13 U7.7 ; R80.2 36.93,109.02 v1(36.47,108.56) 35.96,108.05 19.93,108.05 v1(19.81,107.92) ; R244.2 v1(72.87,14.86)
  BOTTOM w0.127: v1(72.87,14.86) 71.98,15.75 68.04,15.75 64.74,19.05 55.21,19.05 53.94,20.32 53.94,24.13 56.36,26.54 56.36,30.97 55.78,31.55 55.28,31.55 54.3,32.53 54.3,33.76 41.88,46.18 41.88,52.98 38.83,56.03 38.83,62.61 34.09,67.36 29.54,67.36 24.02,72.87 24.02,89.61 21.76,91.87 21.76,95.28 19.65,97.38 19.65,103 19.07,103.58 19.07,107.19 v1(19.81,107.92) ; v1(55.34,120.78) 55.21,120.78 54.83,120.4 54.83,120.14 48.61,113.92 42.34,113.92 36.98,108.56 v1(36.47,108.56)
PC14: length 7
  TOP w0.127: U7.8 58.25,115.43 57.75,114.94 v1(57.75,114.3) 57.75,113.54 R87.2
  BOTTOM w0.127: v1(57.75,114.3) 57.88,114.17 57.88,112.52 58.26,112.14
PC15: length 6.2
  TOP w0.127: R88.2 58.39,114.17 v1(58.39,114.68) 58.62,114.91 58.62,116.69 58.75,116.82 U7.9
  BOTTOM w0.127: SB33.1 58.52,114.81 v1(58.39,114.68)
PD3: length 80.4
  TOP w0.127: U7.117 51.61,133.15 v1(51.28,133.48) ; CN6.15 28.34,127.76 v1(28.37,127.79) ; v1(26.64,156.21) 9.62,156.21 8.73,155.32
  BOTTOM w0.127: v1(26.64,156.21) 26.64,141.94 24.83,140.13 24.83,133.58 23.79,132.54 23.79,129.92 25.93,127.79 v1(28.37,127.79) 29,128.42 32.89,128.42 38.2,133.73 51.02,133.73 v1(51.28,133.48)
PD4: length 205.6
  TOP w0.102: v4(103.96,144.54) 104.44,144.06 U5.G2
  TOP w0.127: v1(32.99,70.61) 34,69.6 50.18,69.6 51.07,68.71 54.2,68.71 54.58,69.09 54.58,69.6 55.39,70.41 U21.43 ; CN6.18 v1(29.69,126.49) ; U2.A2 82.79,151.53 82.52,151.26 82.14,151.26 v4(79.72,153.67) ; U7.118 51.53,132.65 51.02,132.14 v1(51.02,131.95)
  BOTTOM w0.127: v4(103.96,144.54) 103.35,145.15 103.35,148.69 102.97,149.07 102.97,151.03 102.05,151.94 102.05,153.06 101.39,153.72 101.39,154.76 100.68,155.47 100.68,157.71 97.61,160.78 91.59,160.78 87.98,157.18 87.98,156.57 87.37,155.96 81.12,155.96 79.98,154.81 79.98,153.92 v4(79.72,153.67) 78.96,153.67 76.42,151.13 76.42,144.4 75.94,143.92 75.94,142.42 73.3,139.78 72.46,139.78 65.53,132.84 59.4,132.84 57.75,131.19 53.82,131.19 53.05,131.95 v1(51.02,131.95) 48.86,131.95 48.36,132.46 38.83,132.46 32.86,126.49 v1(29.69,126.49) 29.05,126.49 28.44,125.88 28.24,125.88 25.75,123.39 25.75,111 26.85,109.9 26.85,102.14 25.8,101.09 24.99,101.09 24.1,100.2 24.1,98.68 25.19,97.59 25.19,93.2 28.62,89.77 28.62,76.23 29.39,75.45 29.39,74.21 v1(32.99,70.61)
PD5: length 213.7
  TOP w0.102: U5.A5 98.39,147.12 v4(97.83,147.12)
  TOP w0.127: v1(33.62,70.61) 34.39,69.85 50.44,69.85 51.33,68.96 54.07,68.96 54.32,69.22 54.32,69.72 54.89,70.29 U21.44 ; U2.G5 87.58,153.78 87.98,154.18 88.49,154.18 88.67,154.36 88.67,154.91 v5(88.61,154.97) ; CN6.19 v1(28.42,125.22) ; v1(51.4,131.44) 51.4,131.7 51.91,132.21 52.64,132.21 U7.119
  BOTTOM w0.127: v4(97.83,147.12) 97.99,146.96 97.99,144.81 97.56,144.37 97.56,143.41 98.11,142.85 100.78,142.85 101.54,142.09 102.91,142.09 103.6,142.77 103.6,144.15 103.1,144.64 103.1,148.58 101.8,149.89 101.8,152.93 100.3,154.43 100.3,157.53 97.3,160.53 91.81,160.53 88.61,157.33 v5(88.61,154.97) 87.32,154.97 86.58,155.7 81.63,155.7 80.49,154.56 80.49,153.54 80.11,153.16 79.09,153.16 76.93,151 76.93,144.27 76.35,143.69 76.35,142.24 73.5,139.4 72.59,139.4 65.65,132.46 59.51,132.46 57.6,130.56 52.42,130.56 51.53,131.44 v1(51.4,131.44) 50.9,131.44 50.77,131.57 48.86,131.57 48.36,132.08 38.96,132.08 32.76,125.88 29.08,125.88 v1(28.42,125.22) 26,122.81 26,111.3 27.1,110.2 27.1,101.95 26.13,100.97 26.13,98.42 25.76,98.06 25.76,93.54 29.13,90.17 29.13,77.09 29.83,76.39 29.83,74.41 v1(33.62,70.61)
PD6: length 31.3
  TOP w0.127: 48.1,131.44 R53.1 48.74,129.54 v1(48.99,129.54) 49.88,130.43 51.78,130.43 52,130.65 U7.122 ; CN6.24 v1(29.69,122.68)
  BOTTOM w0.127: v1(29.69,122.68) 31.97,122.68 39.59,130.3 46.45,130.3 47.21,129.54 v1(48.99,129.54)
PD7: length 121.1
  TOP w0.127: v1(49.63,129.54) 49.63,129.67 50.01,130.05 51.91,130.05 52.01,130.15 U7.123 ; v1(28.16,122.81) 28.04,122.68 CN6.23 ; v1(34.39,125.86) 34.39,130.81 41.12,137.54 41.12,166.88 43.61,169.37 63.7,169.37 64.61,168.45 64.61,167.51 65.37,166.75 69.06,166.75 69.82,167.51 69.82,168.28 70.58,169.04 71.85,169.04 72.49,168.4 72.49,164.72 73.25,163.96 75.28,163.96 77.69,161.54 R18.2
  BOTTOM w0.127: v1(49.63,129.54) 49.63,129.59 49.17,130.05 47.21,130.05 46.45,130.81 39.34,130.81 v1(34.39,125.86) 31.85,123.32 29.18,123.32 28.67,122.81 v1(28.16,122.81)
PE4: length 63.1
  TOP w0.127: R84.2 53.69,114.17 54.96,115.44 55.47,115.44 55.98,115.95 v1(55.98,116.08) 55.98,116.59 55.75,116.81 U7.3 ; CN7.21 v1(96.87,123.95)
  BOTTOM w0.127: 53.82,113.03 53.82,113.28 54.45,113.92 55.98,113.92 56.36,114.3 56.36,114.94 55.98,115.32 v1(55.98,116.08) 55.98,117.35 58.13,119.51 58.13,122.07 60.93,124.87 60.93,125.48 62.96,127.51 66.39,127.51 68.55,125.35 78.96,125.35 79.47,125.86 89.5,125.86 91.41,123.95 v1(96.87,123.95)
PE5: length 60.7
  TOP w0.127: CN7.23 v1(97,122.68) ; U7.4 56.25,116.69 56.61,116.33 56.61,115.95 57.12,115.44 v1(57.12,115.32) 56.86,115.06 55.72,115.06 55.21,114.55 R85.2
  BOTTOM w0.127: v1(97,122.68) 96.62,123.06 90.65,123.06 88.49,125.22 80.11,125.22 79.72,124.84 68.17,124.84 66.14,126.87 63.21,126.87 61.44,125.09 61.44,124.61 58.9,122.07 58.9,119.25 57.63,117.98 57.63,115.95 57.12,115.44 v1(57.12,115.32) 57.13,115.31 57.13,112.98
PE6: length 61.6
  TOP w0.127: U7.5 56.75,116.7 v1(57.12,116.33) 57.63,115.82 57.63,115.19 56.74,114.3 R86.2 ; CN7.22 v1(98.27,123.95)
  BOTTOM w0.127: v1(98.27,123.95) 97.89,123.95 97.38,123.44 90.9,123.44 88.87,125.48 79.85,125.48 79.47,125.09 68.29,125.09 66.26,127.13 63.09,127.13 61.18,125.22 61.18,124.74 58.39,121.95 58.39,119.25 57.12,117.98 v1(57.12,116.33) 56.61,115.82 56.61,115.06 56.74,114.94 56.74,114.3 55.54,113.11
